
#include <stdio.h>
#include <string.h>
#include <stddef.h>
typedef unsigned char uint8_t;
typedef signed char int8_t;
typedef unsigned short uint16_t;
typedef signed short int16_t;
typedef unsigned int uint32_t;
typedef signed int int32_t;
typedef unsigned __int64 uint64_t;
typedef float fp32;
static uint32_t tick = 1000;
static uint32_t HAL_GetTick(void) { return tick; }
typedef struct { int unused; } UART_HandleTypeDef;
static UART_HandleTypeDef huart6;
static uint8_t transmitted[64];
static uint16_t transmitted_length;
static unsigned int transmit_count;
static int HAL_UART_Transmit(UART_HandleTypeDef *, uint8_t *data, uint16_t length, uint32_t) {
    memcpy(transmitted, data, length); transmitted_length = length; ++transmit_count; return 0;
}
typedef struct { uint8_t bytes[4096]; unsigned int head, tail; } fifo_s_t;
static unsigned int fifo_s_used(fifo_s_t *fifo) { return fifo->head - fifo->tail; }
static uint8_t fifo_s_get(fifo_s_t *fifo) { return fifo->bytes[(fifo->tail++) & 4095]; }
static void fifo_s_puts(fifo_s_t *fifo, const char *data, unsigned int length) {
    while (length--) fifo->bytes[(fifo->head++) & 4095] = (uint8_t)*data++;
}
static struct { struct { struct { uint8_t mode; } speed_vector; } data; } RECEIVE_ROBOT_CMD_DATA;

#pragma pack(push, 1)
#ifndef ROBOMASTER_PROTOCOL_H
#define ROBOMASTER_PROTOCOL_H



#define REFEREE_PROTOCOL_VERSION "2027-V1.0.0-20261029"
#define HEADER_SOF 0xA5U
#define REF_PROTOCOL_MAX_DATA_SIZE 300U
#define REF_PROTOCOL_FRAME_MAX_SIZE 309U
#define REF_PROTOCOL_HEADER_SIZE sizeof(frame_header_struct_t)
#define REF_PROTOCOL_CMD_SIZE 2U
#define REF_PROTOCOL_CRC16_SIZE 2U
#define REF_HEADER_CRC_LEN (REF_PROTOCOL_HEADER_SIZE + REF_PROTOCOL_CRC16_SIZE)
#define REF_HEADER_CRC_CMDID_LEN (REF_PROTOCOL_HEADER_SIZE + REF_PROTOCOL_CMD_SIZE + REF_PROTOCOL_CRC16_SIZE)
#define REF_HEADER_CMDID_LEN (REF_PROTOCOL_HEADER_SIZE + REF_PROTOCOL_CMD_SIZE)
#define REFEREE_SERVER_ID 0x8080U
#define REFEREE_INTERACTION_MAX_DATA 112U

typedef enum {
    GAME_STATE_CMD_ID = 0x0001, GAME_RESULT_CMD_ID = 0x0002,
    GAME_ROBOT_HP_CMD_ID = 0x0003, FIELD_EVENTS_CMD_ID = 0x0101,
    REFEREE_WARNING_CMD_ID = 0x0104, DART_INFO_CMD_ID = 0x0105,
    ROBOT_STATE_CMD_ID = 0x0201, POWER_HEAT_DATA_CMD_ID = 0x0202,
    ROBOT_POS_CMD_ID = 0x0203, BUFF_MUSK_CMD_ID = 0x0204,
    ROBOT_HURT_CMD_ID = 0x0206, SHOOT_DATA_CMD_ID = 0x0207,
    BULLET_REMAINING_CMD_ID = 0x0208, ROBOT_RFID_STATE = 0x0209,
    DART_CLIENT_CMD_ID = 0x020A, GROUND_ROBOT_POSITION_CMD_ID = 0x020B,
    RADAR_MARK_DATA_CMD_ID = 0x020C, SENTRY_INFO_CMD_ID = 0x020D,
    RADAR_INFO_CMD_ID = 0x020E, ROBOT_INTERACTION_DATA_CMD_ID = 0x0301,
    STUDENT_INTERACTIVE_DATA_CMD_ID = 0x0301,
    MAP_COMMAND_CMD_ID = 0x0303, MAP_ROBOT_DATA_CMD_ID = 0x0305,
    MAP_PATH_CMD_ID = 0x0307, CUSTOM_INFO_CMD_ID = 0x0308,
    ROBOT_CUSTOM_DATA_TX_CMD_ID = 0x0310,
    ROBOT_CUSTOM_DATA_RX_CMD_ID = 0x0311
} referee_cmd_id_t;

#pragma pack(push, 1)
typedef  struct {
    uint8_t SOF;
    uint16_t data_length;
    uint8_t seq;
    uint8_t CRC8;
} frame_header_struct_t;
#pragma pack(pop)

typedef enum {
    STEP_HEADER_SOF = 0, STEP_LENGTH_LOW, STEP_LENGTH_HIGH,
    STEP_FRAME_SEQ, STEP_HEADER_CRC8, STEP_DATA_CRC16
} unpack_step_e;
typedef struct {
    frame_header_struct_t *p_header;
    uint16_t data_len;
    uint8_t protocol_packet[REF_PROTOCOL_FRAME_MAX_SIZE];
    unpack_step_e unpack_step;
    uint16_t index;
} unpack_data_t;
#endif

#ifndef REFEREE_H
#define REFEREE_H




typedef enum {
    RED_HEAVY = 1, RED_RESERVED_2 = 2,
    RED_STANDARD_1 = 3, RED_STANDARD_2 = 4, RED_STANDARD_3 = 5,
    RED_AERIAL = 6, RED_SENTRY = 7, RED_DART = 8, RED_RADAR = 9,
    RED_BASE = 10, R_OUTPOST = 11,
    BLUE_HEAVY = 101, BLUE_RESERVED_2 = 102,
    BLUE_STANDARD_1 = 103, BLUE_STANDARD_2 = 104, BLUE_STANDARD_3 = 105,
    BLUE_AERIAL = 106, BLUE_SENTRY = 107, BLUE_DART = 108, BLUE_RADAR = 109,
    BLUE_BASE = 110, B_OUTPOST = 111
} robot_id_t;
typedef enum {
    PROGRESS_UNSTART = 0, PROGRESS_PREPARE, PROGRESS_SELFCHECK,
    PROGRESS_5sCOUNTDOWN, PROGRESS_BATTLE, PROGRESS_CALCULATING
} game_progress_t;

typedef  struct { 
    uint8_t game_type : 4;
    uint8_t game_progress : 4;
    uint16_t stage_remain_time;
    uint64_t SyncTimeStamp;
} game_status_t;
typedef  struct { uint8_t winner; } game_result_t;
typedef  struct { 
    uint16_t ally_1_robot_HP, reserved, ally_3_robot_HP, ally_4_robot_HP;
    int16_t damage_difference;
    uint16_t ally_7_robot_HP, outpost_R_HP, ally_base_HP;
    uint16_t outpost_B_HP, enemy_base_HP, ally_control_degree, enemy_control_degree;
} game_robot_HP_t;
typedef  struct { uint32_t event_data, event_data_2; } event_data_t;
typedef  struct {
    uint8_t level, offending_robot_id, count;
} referee_warning_t;
typedef  struct {
    uint8_t dart_remaining_time;
    uint16_t dart_info;
} dart_info_t;
typedef  struct { 
    uint8_t robot_id, robot_level;
    uint16_t current_HP, maximum_HP;
    uint16_t shooter_barrel_cooling_value, shooter_barrel_heat_limit;
    uint16_t chassis_power_limit;
    float bullet_speed_limit;
    uint8_t power_management_gimbal_output : 1;
    uint8_t power_management_chassis_output : 1;
    uint8_t power_management_shooter_output : 1;
    uint8_t reserved_power_management : 5;
} robot_status_t;
typedef  struct { 
    uint16_t reserved_1, reserved_2;
    float reserved;
    uint16_t buffer_energy, shooter_17mm_barrel_heat, shooter_42mm_barrel_heat;
} power_heat_data_t;
typedef  struct { float x, y, angle; } robot_pos_t; 
typedef  struct { 
    uint8_t recovery_buff;
    uint16_t cooling_buff;
    uint8_t defence_buff, vulnerability_buff;
    uint16_t attack_buff;
} buff_t;
typedef  struct { 
    uint8_t armor_id : 4;
    uint8_t HP_deduction_reason : 4;
    uint16_t hit_sequence;
    int16_t hit_position_x, hit_position_y;
} hurt_data_t;
typedef  struct {
    uint8_t bullet_type, shooter_number, launching_frequency; 
    float initial_speed; 
} shoot_data_t;
typedef  struct {
    uint16_t projectile_allowance_17mm, projectile_allowance_42mm;
    uint16_t remaining_gold_coin, projectile_allowance_fortress;
} projectile_allowance_t;
typedef  struct { uint32_t rfid_status; uint16_t rfid_status_2; } rfid_status_t;
typedef  struct {
    uint8_t dart_launch_opening_status, reserved;
    uint16_t target_change_time, latest_launch_cmd_time;
} dart_client_cmd_t;
typedef  struct {
    float heavyengineer_x, heavyengineer_y, reserved_1, reserved_2;
    float standard_3_x, standard_3_y, standard_4_x, standard_4_y;
    float reserved_3, reserved_4;
} ground_robot_position_t;
typedef  struct { uint16_t mark_progress; } radar_mark_data_t;
typedef  struct {
    uint32_t sentry_info;
    uint16_t sentry_info_2;
    uint64_t sentry_info_3;
} sentry_info_t;
typedef  struct {
    uint8_t radar_info, radar_info_2;
    uint16_t fortify_center_x, fortify_center_y, fortify_radius;
} radar_info_t;
typedef  struct { 
    uint16_t data_cmd_id, sender_id, receiver_id;
    uint8_t user_data[REFEREE_INTERACTION_MAX_DATA];
} robot_interaction_data_t;
typedef  struct { uint8_t delete_type, layer; } interaction_layer_delete_t;
typedef  struct {
    uint8_t figure_name[3];
    uint32_t operate_tpye : 3;
    uint32_t figure_tpye : 3;
    uint32_t layer : 4;
    uint32_t color : 4;
    uint32_t details_a : 9;
    uint32_t details_b : 9;
    uint32_t width : 10;
    uint32_t start_x : 11;
    uint32_t start_y : 11;
    uint32_t details_c : 10;
    uint32_t details_d : 11;
    uint32_t details_e : 11;
} interaction_figure_t;
typedef  struct { interaction_figure_t interaction_figure[2]; } interaction_figure_2_t;
typedef  struct { interaction_figure_t interaction_figure[5]; } interaction_figure_3_t;
typedef  struct { interaction_figure_t interaction_figure[7]; } interaction_figure_4_t;
typedef  struct {
    interaction_figure_t graphic_data;
    uint8_t data[30];
} interaction_character_t;
typedef  struct { uint32_t sentry_cmd; } sentry_cmd_t;
typedef  struct {
    uint8_t radar_cmd, password_cmd, password_1, password_2, password_3;
    uint8_t password_4, password_5, password_6, fortify_cmd;
    uint16_t fortify_center_x, fortify_center_y;
} radar_cmd_t;
typedef  struct {
    float target_position_x, target_position_y;
    uint8_t cmd_keyboard, target_robot_id;
    uint16_t cmd_source;
} map_command_t;
typedef  struct {
    uint16_t opponent_heavyengineer_position_x, opponent_heavyengineer_position_y;
    uint16_t reserved_1, reserved_2;
    uint16_t opponent_infantry_3_position_x, opponent_infantry_3_position_y;
    uint16_t opponent_infantry_4_position_x, opponent_infantry_4_position_y;
    uint16_t reserved_3, reserved_4;
    uint16_t opponent_sentry_position_x, opponent_sentry_position_y;
    uint16_t ally_heavy_position_x, ally_heavy_position_y, reserved_5, reserved_6;
    uint16_t ally_infantry_3_position_x, ally_infantry_3_position_y;
    uint16_t ally_infantry_4_position_x, ally_infantry_4_position_y;
    uint16_t reserved_7, reserved_8, ally_sentry_position_x, ally_sentry_position_y;
} map_robot_data_t;
typedef  struct {
    uint8_t intention;
    uint16_t start_position_x, start_position_y;
    int8_t delta_x[49], delta_y[49];
    uint16_t sender_id;
} map_data_t;
typedef  struct {
    uint16_t sender_id, receiver_id;
    uint8_t user_data[30]; 
} custom_info_t;

typedef  struct { uint8_t data[300]; } robot_custom_data_2_t; 
typedef  struct { uint8_t data[60]; } robot_custom_data_t; 

#define REF_ASSERT_SIZE(type, bytes) typedef char ref_size_##type[(sizeof(type) == (bytes)) ? 1 : -1]
REF_ASSERT_SIZE(frame_header_struct_t, 5);
REF_ASSERT_SIZE(game_status_t, 11); REF_ASSERT_SIZE(game_result_t, 1);
REF_ASSERT_SIZE(game_robot_HP_t, 24); REF_ASSERT_SIZE(event_data_t, 8);
REF_ASSERT_SIZE(referee_warning_t, 3); REF_ASSERT_SIZE(dart_info_t, 3);
REF_ASSERT_SIZE(robot_status_t, 17); REF_ASSERT_SIZE(power_heat_data_t, 14);
REF_ASSERT_SIZE(robot_pos_t, 12); REF_ASSERT_SIZE(buff_t, 7);
REF_ASSERT_SIZE(hurt_data_t, 7); REF_ASSERT_SIZE(shoot_data_t, 7);
REF_ASSERT_SIZE(projectile_allowance_t, 8); REF_ASSERT_SIZE(rfid_status_t, 6);
REF_ASSERT_SIZE(dart_client_cmd_t, 6); REF_ASSERT_SIZE(ground_robot_position_t, 40);
REF_ASSERT_SIZE(radar_mark_data_t, 2); REF_ASSERT_SIZE(sentry_info_t, 14);
REF_ASSERT_SIZE(radar_info_t, 8); REF_ASSERT_SIZE(robot_interaction_data_t, 118);
REF_ASSERT_SIZE(interaction_layer_delete_t, 2); REF_ASSERT_SIZE(interaction_figure_t, 15);
REF_ASSERT_SIZE(interaction_figure_2_t, 30); REF_ASSERT_SIZE(interaction_figure_3_t, 75);
REF_ASSERT_SIZE(interaction_figure_4_t, 105); REF_ASSERT_SIZE(interaction_character_t, 45);
REF_ASSERT_SIZE(sentry_cmd_t, 4); REF_ASSERT_SIZE(radar_cmd_t, 13);
REF_ASSERT_SIZE(map_command_t, 12); REF_ASSERT_SIZE(map_robot_data_t, 48);
REF_ASSERT_SIZE(map_data_t, 105); REF_ASSERT_SIZE(custom_info_t, 34);
REF_ASSERT_SIZE(robot_custom_data_2_t, 300); REF_ASSERT_SIZE(robot_custom_data_t, 60);
#undef REF_ASSERT_SIZE

extern frame_header_struct_t referee_receive_header, referee_send_header;
extern game_status_t game_state;
extern game_result_t game_result;
extern game_robot_HP_t game_robot_HP;
extern event_data_t field_event;
extern referee_warning_t referee_warning;
extern dart_info_t dart_info;
extern robot_status_t robot_state;
extern power_heat_data_t power_heat_data;
extern robot_pos_t game_robot_pos;
extern buff_t buff;
extern hurt_data_t robot_hurt;
extern shoot_data_t shoot_data;
extern projectile_allowance_t projectile_allowance;
extern rfid_status_t robot_rfid;
extern dart_client_cmd_t dart_client_cmd;
extern ground_robot_position_t ground_robot_position;
extern radar_mark_data_t radar_mark_data;
extern sentry_info_t SentryInfo;
extern radar_info_t RadarInfo;
extern robot_interaction_data_t robot_interaction_data;
extern uint16_t robot_interaction_user_data_length;
extern interaction_layer_delete_t interaction_layer_delete;
extern interaction_figure_t interaction_figure;
extern interaction_figure_2_t interaction_figure_2;
extern interaction_figure_3_t interaction_figure_3;
extern interaction_figure_4_t interaction_figure_4;
extern interaction_character_t interaction_character;
extern sentry_cmd_t sentry_cmd;
extern radar_cmd_t radar_cmd;
extern map_command_t map_command;
extern map_robot_data_t map_robot_data;
extern map_data_t map_data;
extern custom_info_t custom_info;
extern robot_custom_data_2_t robot_custom_data_2;
extern robot_custom_data_t robot_custom_data;
extern volatile uint32_t referee_rx_valid_frames;
extern volatile uint32_t referee_last_rx_tick;
extern volatile uint16_t referee_last_cmd_id;
void init_referee_struct_data(void);
uint8_t referee_data_solve(const uint8_t *frame, uint16_t frame_length);

uint8_t referee_team_color(uint8_t robot_id);
#endif

#ifndef REFEREE_USART_TASK_H
#define REFEREE_USART_TASK_H




#define USART_RX_BUF_LENGHT 512U
#define REFEREE_FIFO_BUF_LENGTH 2048U
#define SENTRY_CMD_POSTURE_SHIFT 21U
#define SENTRY_CMD_POSTURE_MASK (7UL << SENTRY_CMD_POSTURE_SHIFT)
#define SENTRY_CMD_ACTIVATE_RUNE (1UL << 24)

typedef frame_header_struct_t frame_header_t;
typedef  struct {
    uint16_t data_cmd_id, sender_id, receiver_id;
    sentry_cmd_t SENTRY;
} data_header_t;
typedef  struct {
    frame_header_t framehead;
    uint16_t CMD_ID;
    data_header_t datahead;
} sentry_fh;

typedef struct {
    uint16_t exchanged_bullets;
    uint8_t remote_bullet_cnt, remote_heal_cnt;
    uint8_t can_free_respawn, can_pay_respawn;
    uint16_t respawn_gold_cost;
    uint8_t is_out_of_combat;
    uint16_t team_17mm_remaining;
    uint8_t current_posture, can_activate_rune, is_enhanced_posture;
    uint8_t attack_remaining_time, defend_remaining_time, move_remaining_time;
    uint8_t enhanced_attack_remaining_time, enhanced_defend_remaining_time;
    uint8_t enhanced_move_remaining_time;
} sentry_info_extracted_t;


typedef struct {
    uint8_t supply_zone_activated, small_rune_status, big_rune_status;
    uint8_t r_fortress_gain, b_fortress_gain, r_base_gain, b_base_gain;
    uint8_t allied_high_ground_gain, r_central_highland_gain, b_central_highland_gain;
    uint8_t r_outpost_gain, b_outpost_gain;
    uint8_t r_outpost_control, b_outpost_control, r_base_control, b_base_control;
    uint16_t enemy_dart_last_hit_time;
    uint8_t enemy_dart_last_hit_target;
    uint8_t r_highland_activation, r_highland_control;
    uint8_t b_highland_activation, b_highland_control;
    uint8_t central_activation, central_control;
} event_data_parsed_t;

extern uint8_t Vision_ID;
extern sentry_info_extracted_t info;
extern event_data_parsed_t event_info;

extern volatile uint8_t sentry_activate_rune;
void robot_id(void);
void referee_usart_task(void const *argument);
void send_test(sentry_fh *fh);
void get_sentry_info(sentry_info_extracted_t *result);
void get_event_info(event_data_parsed_t *result);
#endif

#pragma pack(pop)


const uint8_t CRC8_INIT = 0xff;
const uint8_t CRC8_table[256] =
{
    0x00, 0x5e, 0xbc, 0xe2, 0x61, 0x3f, 0xdd, 0x83, 0xc2, 0x9c, 0x7e, 0x20, 0xa3, 0xfd, 0x1f, 0x41,
    0x9d, 0xc3, 0x21, 0x7f, 0xfc, 0xa2, 0x40, 0x1e, 0x5f, 0x01, 0xe3, 0xbd, 0x3e, 0x60, 0x82, 0xdc,
    0x23, 0x7d, 0x9f, 0xc1, 0x42, 0x1c, 0xfe, 0xa0, 0xe1, 0xbf, 0x5d, 0x03, 0x80, 0xde, 0x3c, 0x62,
    0xbe, 0xe0, 0x02, 0x5c, 0xdf, 0x81, 0x63, 0x3d, 0x7c, 0x22, 0xc0, 0x9e, 0x1d, 0x43, 0xa1, 0xff,
    0x46, 0x18, 0xfa, 0xa4, 0x27, 0x79, 0x9b, 0xc5, 0x84, 0xda, 0x38, 0x66, 0xe5, 0xbb, 0x59, 0x07,
    0xdb, 0x85, 0x67, 0x39, 0xba, 0xe4, 0x06, 0x58, 0x19, 0x47, 0xa5, 0xfb, 0x78, 0x26, 0xc4, 0x9a,
    0x65, 0x3b, 0xd9, 0x87, 0x04, 0x5a, 0xb8, 0xe6, 0xa7, 0xf9, 0x1b, 0x45, 0xc6, 0x98, 0x7a, 0x24,
    0xf8, 0xa6, 0x44, 0x1a, 0x99, 0xc7, 0x25, 0x7b, 0x3a, 0x64, 0x86, 0xd8, 0x5b, 0x05, 0xe7, 0xb9,
    0x8c, 0xd2, 0x30, 0x6e, 0xed, 0xb3, 0x51, 0x0f, 0x4e, 0x10, 0xf2, 0xac, 0x2f, 0x71, 0x93, 0xcd,
    0x11, 0x4f, 0xad, 0xf3, 0x70, 0x2e, 0xcc, 0x92, 0xd3, 0x8d, 0x6f, 0x31, 0xb2, 0xec, 0x0e, 0x50,
    0xaf, 0xf1, 0x13, 0x4d, 0xce, 0x90, 0x72, 0x2c, 0x6d, 0x33, 0xd1, 0x8f, 0x0c, 0x52, 0xb0, 0xee,
    0x32, 0x6c, 0x8e, 0xd0, 0x53, 0x0d, 0xef, 0xb1, 0xf0, 0xae, 0x4c, 0x12, 0x91, 0xcf, 0x2d, 0x73,
    0xca, 0x94, 0x76, 0x28, 0xab, 0xf5, 0x17, 0x49, 0x08, 0x56, 0xb4, 0xea, 0x69, 0x37, 0xd5, 0x8b,
    0x57, 0x09, 0xeb, 0xb5, 0x36, 0x68, 0x8a, 0xd4, 0x95, 0xcb, 0x29, 0x77, 0xf4, 0xaa, 0x48, 0x16,
    0xe9, 0xb7, 0x55, 0x0b, 0x88, 0xd6, 0x34, 0x6a, 0x2b, 0x75, 0x97, 0xc9, 0x4a, 0x14, 0xf6, 0xa8,
    0x74, 0x2a, 0xc8, 0x96, 0x15, 0x4b, 0xa9, 0xf7, 0xb6, 0xe8, 0x0a, 0x54, 0xd7, 0x89, 0x6b, 0x35,
};
uint16_t CRC16_INIT = 0xffff;
const uint16_t wCRC_table[256] =
{
0x0000, 0x1189, 0x2312, 0x329b, 0x4624, 0x57ad, 0x6536, 0x74bf,
0x8c48, 0x9dc1, 0xaf5a, 0xbed3, 0xca6c, 0xdbe5, 0xe97e, 0xf8f7,
0x1081, 0x0108, 0x3393, 0x221a, 0x56a5, 0x472c, 0x75b7, 0x643e,
0x9cc9, 0x8d40, 0xbfdb, 0xae52, 0xdaed, 0xcb64, 0xf9ff, 0xe876,
0x2102, 0x308b, 0x0210, 0x1399, 0x6726, 0x76af, 0x4434, 0x55bd,
0xad4a, 0xbcc3, 0x8e58, 0x9fd1, 0xeb6e, 0xfae7, 0xc87c, 0xd9f5,
0x3183, 0x200a, 0x1291, 0x0318, 0x77a7, 0x662e, 0x54b5, 0x453c,
0xbdcb, 0xac42, 0x9ed9, 0x8f50, 0xfbef, 0xea66, 0xd8fd, 0xc974,
0x4204, 0x538d, 0x6116, 0x709f, 0x0420, 0x15a9, 0x2732, 0x36bb,
0xce4c, 0xdfc5, 0xed5e, 0xfcd7, 0x8868, 0x99e1, 0xab7a, 0xbaf3,
0x5285, 0x430c, 0x7197, 0x601e, 0x14a1, 0x0528, 0x37b3, 0x263a,
0xdecd, 0xcf44, 0xfddf, 0xec56, 0x98e9, 0x8960, 0xbbfb, 0xaa72,
0x6306, 0x728f, 0x4014, 0x519d, 0x2522, 0x34ab, 0x0630, 0x17b9,
0xef4e, 0xfec7, 0xcc5c, 0xddd5, 0xa96a, 0xb8e3, 0x8a78, 0x9bf1,
0x7387, 0x620e, 0x5095, 0x411c, 0x35a3, 0x242a, 0x16b1, 0x0738,
0xffcf, 0xee46, 0xdcdd, 0xcd54, 0xb9eb, 0xa862, 0x9af9, 0x8b70,
0x8408, 0x9581, 0xa71a, 0xb693, 0xc22c, 0xd3a5, 0xe13e, 0xf0b7,
0x0840, 0x19c9, 0x2b52, 0x3adb, 0x4e64, 0x5fed, 0x6d76, 0x7cff,
0x9489, 0x8500, 0xb79b, 0xa612, 0xd2ad, 0xc324, 0xf1bf, 0xe036,
0x18c1, 0x0948, 0x3bd3, 0x2a5a, 0x5ee5, 0x4f6c, 0x7df7, 0x6c7e,
0xa50a, 0xb483, 0x8618, 0x9791, 0xe32e, 0xf2a7, 0xc03c, 0xd1b5,
0x2942, 0x38cb, 0x0a50, 0x1bd9, 0x6f66, 0x7eef, 0x4c74, 0x5dfd,
0xb58b, 0xa402, 0x9699, 0x8710, 0xf3af, 0xe226, 0xd0bd, 0xc134,
0x39c3, 0x284a, 0x1ad1, 0x0b58, 0x7fe7, 0x6e6e, 0x5cf5, 0x4d7c,
0xc60c, 0xd785, 0xe51e, 0xf497, 0x8028, 0x91a1, 0xa33a, 0xb2b3,
0x4a44, 0x5bcd, 0x6956, 0x78df, 0x0c60, 0x1de9, 0x2f72, 0x3efb,
0xd68d, 0xc704, 0xf59f, 0xe416, 0x90a9, 0x8120, 0xb3bb, 0xa232,
0x5ac5, 0x4b4c, 0x79d7, 0x685e, 0x1ce1, 0x0d68, 0x3ff3, 0x2e7a,
0xe70e, 0xf687, 0xc41c, 0xd595, 0xa12a, 0xb0a3, 0x8238, 0x93b1,
0x6b46, 0x7acf, 0x4854, 0x59dd, 0x2d62, 0x3ceb, 0x0e70, 0x1ff9,
0xf78f, 0xe606, 0xd49d, 0xc514, 0xb1ab, 0xa022, 0x92b9, 0x8330,
0x7bc7, 0x6a4e, 0x58d5, 0x495c, 0x3de3, 0x2c6a, 0x1ef1, 0x0f78
};




uint8_t get_CRC8_check_sum(unsigned char *pch_message,unsigned int dw_length,unsigned char ucCRC8)
{
    unsigned char uc_index;
    while (dw_length--)
    {
        uc_index = ucCRC8^(*pch_message++);
        ucCRC8 = CRC8_table[uc_index];
    }
    return(ucCRC8);
}




uint32_t verify_CRC8_check_sum(unsigned char *pch_message, unsigned int dw_length)
{
    unsigned char ucExpected = 0;
    if ((pch_message == 0) || (dw_length <= 2))
    {
        return 0;
    }
    ucExpected = get_CRC8_check_sum (pch_message, dw_length - 1, CRC8_INIT);
    return ( ucExpected == pch_message[dw_length - 1] );
}




void append_CRC8_check_sum(unsigned char *pch_message, unsigned int dw_length)
{
    unsigned char ucCRC = 0;
    if ((pch_message == 0) || (dw_length <= 2))
    {
        return;
    }
    ucCRC = get_CRC8_check_sum((unsigned char *)pch_message, dw_length - 1, CRC8_INIT);
    pch_message[dw_length - 1] = ucCRC;
}




uint16_t get_CRC16_check_sum(uint8_t *pch_message,uint32_t dw_length,uint16_t wCRC)
{
    uint8_t chData;
    if (pch_message == NULL)
    {
        return 0xFFFF;
    }
    while(dw_length--)
    {
        chData = *pch_message++;
        (wCRC) = ((uint16_t)(wCRC) >> 8) ^ wCRC_table[((uint16_t)(wCRC) ^ (uint16_t)(chData)) & 0x00ff];
    }
    return wCRC;
}




uint32_t verify_CRC16_check_sum(uint8_t *pchMessage, uint32_t dwLength)
{
    uint16_t wExpected = 0;
    if ((pchMessage == NULL) || (dwLength <= 2))
    {
        return 0;
    }
    wExpected = get_CRC16_check_sum(pchMessage, dwLength - 2, CRC16_INIT);
    return ((wExpected & 0xff) == pchMessage[dwLength - 2] && ((wExpected >> 8) & 0xff) == pchMessage[dwLength - 1]);
}




void append_CRC16_check_sum(uint8_t * pchMessage,uint32_t dwLength)
{
    uint16_t wCRC = 0;
    if ((pchMessage == NULL) || (dwLength <= 2))
    {
        return;
    }
    wCRC = get_CRC16_check_sum ( (uint8_t *)pchMessage, dwLength-2, CRC16_INIT );
    pchMessage[dwLength-2] = (uint8_t)(wCRC & 0x00ff);
    pchMessage[dwLength-1] = (uint8_t)((wCRC >> 8)& 0x00ff);
}





frame_header_struct_t referee_receive_header, referee_send_header;
game_status_t game_state;
game_result_t game_result;
game_robot_HP_t game_robot_HP;
event_data_t field_event;
referee_warning_t referee_warning;
dart_info_t dart_info;
robot_status_t robot_state;
power_heat_data_t power_heat_data;
robot_pos_t game_robot_pos;
buff_t buff;
hurt_data_t robot_hurt;
shoot_data_t shoot_data;
projectile_allowance_t projectile_allowance;
rfid_status_t robot_rfid;
dart_client_cmd_t dart_client_cmd;
ground_robot_position_t ground_robot_position;
radar_mark_data_t radar_mark_data;
sentry_info_t SentryInfo;
radar_info_t RadarInfo;
robot_interaction_data_t robot_interaction_data;
uint16_t robot_interaction_user_data_length;
interaction_layer_delete_t interaction_layer_delete;
interaction_figure_t interaction_figure;
interaction_figure_2_t interaction_figure_2;
interaction_figure_3_t interaction_figure_3;
interaction_figure_4_t interaction_figure_4;
interaction_character_t interaction_character;
sentry_cmd_t sentry_cmd;
radar_cmd_t radar_cmd;
map_command_t map_command;
map_robot_data_t map_robot_data;
map_data_t map_data;
custom_info_t custom_info;
robot_custom_data_2_t robot_custom_data_2;
robot_custom_data_t robot_custom_data;
volatile uint32_t referee_rx_valid_frames;
volatile uint32_t referee_last_rx_tick;
volatile uint16_t referee_last_cmd_id;

void init_referee_struct_data(void)
{
#define CLEAR(object) memset(&(object), 0, sizeof(object))
    CLEAR(referee_receive_header); CLEAR(referee_send_header);
    CLEAR(game_state); CLEAR(game_result); CLEAR(game_robot_HP);
    CLEAR(field_event); CLEAR(referee_warning); CLEAR(dart_info);
    CLEAR(robot_state); CLEAR(power_heat_data); CLEAR(game_robot_pos);
    CLEAR(buff); CLEAR(robot_hurt); CLEAR(shoot_data); CLEAR(projectile_allowance);
    CLEAR(robot_rfid); CLEAR(dart_client_cmd); CLEAR(ground_robot_position);
    CLEAR(radar_mark_data); CLEAR(SentryInfo); CLEAR(RadarInfo);
    CLEAR(robot_interaction_data); CLEAR(interaction_layer_delete);
    CLEAR(interaction_figure); CLEAR(interaction_figure_2);
    CLEAR(interaction_figure_3); CLEAR(interaction_figure_4);
    CLEAR(interaction_character); CLEAR(sentry_cmd); CLEAR(radar_cmd);
    CLEAR(map_command); CLEAR(map_robot_data); CLEAR(map_data); CLEAR(custom_info);
    CLEAR(robot_custom_data_2); CLEAR(robot_custom_data);
#undef CLEAR
    robot_interaction_user_data_length = 0U;
    referee_rx_valid_frames = 0U;
    referee_last_rx_tick = 0U;
    referee_last_cmd_id = 0U;
}

uint8_t referee_team_color(uint8_t id)
{
    if (id >= 1U && id <= 11U && id != 2U) return 0U;
    if (id >= 101U && id <= 111U && id != 102U) return 1U;
    return 0xFFU;
}

static uint16_t referee_u16(const uint8_t *data)
{
    return (uint16_t)((uint16_t)data[0] | ((uint16_t)data[1] << 8));
}

static uint8_t referee_interaction_solve(const uint8_t *data, uint16_t length)
{
    uint16_t sub_id, user_length, expected = 0U;
    void *destination = NULL;
    if (length < 6U || length > sizeof(robot_interaction_data)) return 0U;
    sub_id = referee_u16(data);
    user_length = length - 6U;
    if (sub_id >= 0x0200U && sub_id <= 0x02FFU) {
        expected = user_length;
    } else {
        switch (sub_id) {
#define INTERACTION_CASE(id, object) case id: destination = &(object); expected = sizeof(object); break
        INTERACTION_CASE(0x0100U, interaction_layer_delete);
        INTERACTION_CASE(0x0101U, interaction_figure);
        INTERACTION_CASE(0x0102U, interaction_figure_2);
        INTERACTION_CASE(0x0103U, interaction_figure_3);
        INTERACTION_CASE(0x0104U, interaction_figure_4);
        INTERACTION_CASE(0x0110U, interaction_character);
        INTERACTION_CASE(0x0120U, sentry_cmd);
        INTERACTION_CASE(0x0121U, radar_cmd);
#undef INTERACTION_CASE
        default: return 0U;
        }
    }
    if (user_length != expected) return 0U;
    
    memset(&robot_interaction_data, 0, sizeof(robot_interaction_data));
    memcpy(&robot_interaction_data, data, length);
    robot_interaction_user_data_length = user_length;
    if (destination != NULL) memcpy(destination, data + 6U, user_length);
    return 1U;
}

uint8_t referee_data_solve(const uint8_t *frame, uint16_t frame_length)
{
    uint16_t length, command, expected = 0U;
    void *destination = NULL;
    if (frame == NULL || frame_length < REF_HEADER_CRC_CMDID_LEN ||
        frame_length > REF_PROTOCOL_FRAME_MAX_SIZE || frame[0] != HEADER_SOF) return 0U;
    length = referee_u16(frame + 1U);
    if ((uint32_t)length + REF_HEADER_CRC_CMDID_LEN != frame_length) return 0U;
    if (!verify_CRC8_check_sum((uint8_t *)frame, REF_PROTOCOL_HEADER_SIZE) ||
        !verify_CRC16_check_sum((uint8_t *)frame, frame_length)) return 0U;
    command = referee_u16(frame + REF_PROTOCOL_HEADER_SIZE);
    if (command == ROBOT_INTERACTION_DATA_CMD_ID) {
        if (!referee_interaction_solve(frame + REF_HEADER_CMDID_LEN, length)) return 0U;
    } else {
        switch (command) {
#define DATA_CASE(id, object) case id: destination = &(object); expected = sizeof(object); break
        DATA_CASE(GAME_STATE_CMD_ID, game_state);
        DATA_CASE(GAME_RESULT_CMD_ID, game_result);
        DATA_CASE(GAME_ROBOT_HP_CMD_ID, game_robot_HP);
        DATA_CASE(FIELD_EVENTS_CMD_ID, field_event);
        DATA_CASE(REFEREE_WARNING_CMD_ID, referee_warning);
        DATA_CASE(DART_INFO_CMD_ID, dart_info);
        DATA_CASE(ROBOT_STATE_CMD_ID, robot_state);
        DATA_CASE(POWER_HEAT_DATA_CMD_ID, power_heat_data);
        DATA_CASE(ROBOT_POS_CMD_ID, game_robot_pos);
        DATA_CASE(BUFF_MUSK_CMD_ID, buff);
        DATA_CASE(ROBOT_HURT_CMD_ID, robot_hurt);
        DATA_CASE(SHOOT_DATA_CMD_ID, shoot_data);
        DATA_CASE(BULLET_REMAINING_CMD_ID, projectile_allowance);
        DATA_CASE(ROBOT_RFID_STATE, robot_rfid);
        DATA_CASE(DART_CLIENT_CMD_ID, dart_client_cmd);
        DATA_CASE(GROUND_ROBOT_POSITION_CMD_ID, ground_robot_position);
        DATA_CASE(RADAR_MARK_DATA_CMD_ID, radar_mark_data);
        DATA_CASE(SENTRY_INFO_CMD_ID, SentryInfo);
        DATA_CASE(RADAR_INFO_CMD_ID, RadarInfo);
        DATA_CASE(MAP_COMMAND_CMD_ID, map_command);
        DATA_CASE(MAP_ROBOT_DATA_CMD_ID, map_robot_data);
        DATA_CASE(MAP_PATH_CMD_ID, map_data);
        DATA_CASE(CUSTOM_INFO_CMD_ID, custom_info);
        DATA_CASE(ROBOT_CUSTOM_DATA_TX_CMD_ID, robot_custom_data_2);
        DATA_CASE(ROBOT_CUSTOM_DATA_RX_CMD_ID, robot_custom_data);
#undef DATA_CASE
        default: return 0U;
        }
        if (length != expected) return 0U;
        memcpy(destination, frame + REF_HEADER_CMDID_LEN, length);
    }
    memcpy(&referee_receive_header, frame, REF_PROTOCOL_HEADER_SIZE);
    referee_last_cmd_id = command;
    referee_last_rx_tick = HAL_GetTick();
    referee_rx_valid_frames++;
    return 1U;
}



uint8_t get_robot_id(void) { return robot_state.robot_id; }
uint8_t get_robot_level(void) { return robot_state.robot_level; }
uint16_t get_robot_max_HP(void) { return robot_state.maximum_HP; }
uint16_t get_robot_remain_HP(void) { return robot_state.current_HP; }
uint16_t get_chassis_buffer_energy(void) { return power_heat_data.buffer_energy; }
uint16_t Chassis_Power_Limit(void) { return robot_state.chassis_power_limit; }
uint16_t get_shooter_cooling_value(void) { return robot_state.shooter_barrel_cooling_value; }
uint16_t get_shooter_heat_limit(void) { return robot_state.shooter_barrel_heat_limit; }
uint16_t get_shooter_17mm_heat(void) { return power_heat_data.shooter_17mm_barrel_heat; }
uint16_t get_shooter_42mm_heat(void) { return power_heat_data.shooter_42mm_barrel_heat; }
fp32 get_bullet_speed_limit(void) { return robot_state.bullet_speed_limit; }
fp32 get_bullet_initial_speed(void) { return shoot_data.initial_speed; }
uint8_t get_bullet_launching_frequency(void) { return shoot_data.launching_frequency; }
int MyColour(void) {
    uint8_t color = referee_team_color(robot_state.robot_id);
    return color <= 1U ? (int)color : -1;
}

static fifo_s_t referee_fifo;
static unpack_data_t referee_unpack_obj;
static uint8_t Vision_ID, UI_Seq1, hhg_test[19];
static volatile uint8_t sentry_activate_rune;

void robot_id(void)
{
    uint8_t team = referee_team_color(robot_state.robot_id);
    
    Vision_ID = (team <= 1U) ? (uint8_t)(1U - team) : 0xFFU;
}
void send_test(sentry_fh *fh)
{
    uint8_t posture;
    uint32_t command = 0U;
    sentry_info_extracted_t status;
    if (fh == NULL || (robot_state.robot_id != RED_SENTRY &&
                       robot_state.robot_id != BLUE_SENTRY)) return;
    memset(fh, 0, sizeof(*fh));
    fh->framehead.SOF = HEADER_SOF;
    fh->framehead.data_length = sizeof(data_header_t);
    fh->framehead.seq = UI_Seq1++;
    fh->CMD_ID = ROBOT_INTERACTION_DATA_CMD_ID;
    fh->datahead.data_cmd_id = 0x0120U;
    fh->datahead.sender_id = robot_state.robot_id;
    fh->datahead.receiver_id = REFEREE_SERVER_ID;
    get_sentry_info(&status);
    if (status.can_free_respawn) command |= 1UL;
    posture = (uint8_t)RECEIVE_ROBOT_CMD_DATA.data.speed_vector.mode;
    if (posture < 1U || posture > 6U) posture = 3U;
    
    command |= ((uint32_t)posture << SENTRY_CMD_POSTURE_SHIFT);
    if (sentry_activate_rune) command |= SENTRY_CMD_ACTIVATE_RUNE;
    fh->datahead.SENTRY.sentry_cmd = command;
    
    memcpy(hhg_test, fh, sizeof(*fh));
    append_CRC8_check_sum(hhg_test, REF_PROTOCOL_HEADER_SIZE);
    fh->framehead.CRC8 = hhg_test[4];
    append_CRC16_check_sum(hhg_test, sizeof(hhg_test));
    (void)HAL_UART_Transmit(&huart6, hhg_test, sizeof(hhg_test), 20U);
}
void get_sentry_info(sentry_info_extracted_t *result)
{
    uint32_t first;
    uint16_t second;
    uint64_t third;
    if (result == NULL) return;
    first = SentryInfo.sentry_info;
    second = SentryInfo.sentry_info_2;
    third = SentryInfo.sentry_info_3;
    result->exchanged_bullets = (uint16_t)(first & 0x7FFU);
    result->remote_bullet_cnt = (uint8_t)((first >> 11) & 0x0FU);
    result->remote_heal_cnt = (uint8_t)((first >> 15) & 0x0FU);
    result->can_free_respawn = (uint8_t)((first >> 19) & 1U);
    result->can_pay_respawn = (uint8_t)((first >> 20) & 1U);
    result->respawn_gold_cost = (uint16_t)((first >> 21) & 0x3FFU);
    result->is_out_of_combat = (uint8_t)(second & 1U);
    result->team_17mm_remaining = (uint16_t)((second >> 1) & 0x7FFU);
    result->current_posture = (uint8_t)((second >> 12) & 3U);
    result->can_activate_rune = (uint8_t)((second >> 14) & 1U);
    result->is_enhanced_posture = (uint8_t)((second >> 15) & 1U);
    result->attack_remaining_time = (uint8_t)(third & 0xFFU);
    result->defend_remaining_time = (uint8_t)((third >> 8) & 0xFFU);
    result->move_remaining_time = (uint8_t)((third >> 16) & 0xFFU);
    result->enhanced_attack_remaining_time = (uint8_t)((third >> 32) & 0xFFU);
    result->enhanced_defend_remaining_time = (uint8_t)((third >> 40) & 0xFFU);
    result->enhanced_move_remaining_time = (uint8_t)((third >> 48) & 0xFFU);
}
void get_event_info(event_data_parsed_t *result)
{
    uint32_t first, second;
    if (result == NULL) return;
    first = field_event.event_data;
    second = field_event.event_data_2;
    result->supply_zone_activated = (uint8_t)(first & 1U);
    result->small_rune_status = (uint8_t)((first >> 1) & 3U);
    result->big_rune_status = (uint8_t)((first >> 3) & 3U);
    result->r_fortress_gain = (uint8_t)((first >> 5) & 7U);
    result->b_fortress_gain = (uint8_t)((first >> 8) & 7U);
    result->r_base_gain = (uint8_t)((first >> 11) & 7U);
    result->b_base_gain = (uint8_t)((first >> 14) & 7U);
    result->allied_high_ground_gain = (uint8_t)((first >> 17) & 1U);
    result->r_central_highland_gain = (uint8_t)((first >> 18) & 3U);
    result->b_central_highland_gain = (uint8_t)((first >> 20) & 3U);
    result->r_outpost_gain = (uint8_t)((first >> 22) & 7U);
    result->b_outpost_gain = (uint8_t)((first >> 25) & 7U);
    result->r_outpost_control = (uint8_t)((first >> 28) & 3U);
    result->b_outpost_control = (uint8_t)((first >> 30) & 3U);
    result->r_base_control = (uint8_t)(second & 3U);
    result->b_base_control = (uint8_t)((second >> 2) & 3U);
    result->enemy_dart_last_hit_time = (uint16_t)((second >> 4) & 0x1FFU);
    result->enemy_dart_last_hit_target = (uint8_t)((second >> 13) & 7U);
    result->r_highland_activation = (uint8_t)((second >> 16) & 3U);
    result->r_highland_control = (uint8_t)((second >> 18) & 3U);
    result->b_highland_activation = (uint8_t)((second >> 20) & 3U);
    result->b_highland_control = (uint8_t)((second >> 22) & 3U);
    result->central_activation = (uint8_t)((second >> 24) & 3U);
    result->central_control = (uint8_t)((second >> 26) & 3U);
}
static void referee_unpack_fifo_data(void)
{
    uint8_t byte;
    unpack_data_t *packet = &referee_unpack_obj;
    while (fifo_s_used(&referee_fifo)) {
        byte = (uint8_t)fifo_s_get(&referee_fifo);
        switch (packet->unpack_step) {
        case STEP_HEADER_SOF:
            packet->index = 0U;
            if (byte == HEADER_SOF) {
                packet->protocol_packet[packet->index++] = byte;
                packet->unpack_step = STEP_LENGTH_LOW;
            }
            break;
        case STEP_LENGTH_LOW:
            packet->data_len = byte;
            packet->protocol_packet[packet->index++] = byte;
            packet->unpack_step = STEP_LENGTH_HIGH;
            break;
        case STEP_LENGTH_HIGH:
            packet->data_len |= (uint16_t)((uint16_t)byte << 8);
            packet->protocol_packet[packet->index++] = byte;
            if (packet->data_len <= REF_PROTOCOL_MAX_DATA_SIZE) {
                packet->unpack_step = STEP_FRAME_SEQ;
            } else {
                packet->unpack_step = STEP_HEADER_SOF;
                packet->index = 0U;
            }
            break;
        case STEP_FRAME_SEQ:
            packet->protocol_packet[packet->index++] = byte;
            packet->unpack_step = STEP_HEADER_CRC8;
            break;
        case STEP_HEADER_CRC8:
            packet->protocol_packet[packet->index++] = byte;
            if (verify_CRC8_check_sum(packet->protocol_packet, REF_PROTOCOL_HEADER_SIZE)) {
                packet->unpack_step = STEP_DATA_CRC16;
            } else {
                packet->unpack_step = STEP_HEADER_SOF;
                packet->index = 0U;
            }
            break;
        case STEP_DATA_CRC16:
            packet->protocol_packet[packet->index++] = byte;
            if (packet->index == packet->data_len + REF_HEADER_CRC_CMDID_LEN) {
                uint16_t total = packet->index;
                packet->unpack_step = STEP_HEADER_SOF;
                packet->index = 0U;
                (void)referee_data_solve(packet->protocol_packet, total);
            }
            break;
        default:
            packet->unpack_step = STEP_HEADER_SOF;
            packet->index = 0U;
            break;
        }
    }
}
static uint8_t f_game[] = {0xa5,0x0b,0x00,0x37,0x3f,0x01,0x00,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x8b,0x78};
static uint8_t short_game[] = {0xa5,0x0a,0x00,0x37,0x94,0x01,0x00,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0xcf,0x8a};
static uint8_t long_game[] = {0xa5,0x0c,0x00,0x37,0x45,0x01,0x00,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x00,0x9d,0x75};
static uint8_t f_result[] = {0xa5,0x01,0x00,0x37,0x55,0x02,0x00,0x07,0x61,0x97};
static uint8_t short_result[] = {0xa5,0x00,0x00,0x37,0xfe,0x02,0x00,0xfe,0xd2};
static uint8_t long_result[] = {0xa5,0x02,0x00,0x37,0xb1,0x02,0x00,0x07,0x00,0x3e,0xfe};
static uint8_t f_hp[] = {0xa5,0x18,0x00,0x37,0x91,0x03,0x00,0x20,0x03,0x00,0x00,0xfa,0x00,0x2c,0x01,0xbf,0xfe,0x58,0x02,0xb0,0x04,0x88,0x13,0x4c,0x04,0xa0,0x0f,0x2a,0x00,0x2b,0x00,0x4a,0x1e};
static uint8_t short_hp[] = {0xa5,0x17,0x00,0x37,0xce,0x03,0x00,0x20,0x03,0x00,0x00,0xfa,0x00,0x2c,0x01,0xbf,0xfe,0x58,0x02,0xb0,0x04,0x88,0x13,0x4c,0x04,0xa0,0x0f,0x2a,0x00,0x2b,0x1e,0xef};
static uint8_t long_hp[] = {0xa5,0x19,0x00,0x37,0x3a,0x03,0x00,0x20,0x03,0x00,0x00,0xfa,0x00,0x2c,0x01,0xbf,0xfe,0x58,0x02,0xb0,0x04,0x88,0x13,0x4c,0x04,0xa0,0x0f,0x2a,0x00,0x2b,0x00,0x00,0xbc,0x11};
static uint8_t f_event[] = {0xa5,0x08,0x00,0x37,0xdb,0x01,0x01,0x8d,0x53,0x3a,0x95,0x49,0xda,0x9b,0x07,0xac,0x48};
static uint8_t short_event[] = {0xa5,0x07,0x00,0x37,0x84,0x01,0x01,0x8d,0x53,0x3a,0x95,0x49,0xda,0x9b,0x33,0xe3};
static uint8_t long_event[] = {0xa5,0x09,0x00,0x37,0x70,0x01,0x01,0x8d,0x53,0x3a,0x95,0x49,0xda,0x9b,0x07,0x00,0x76,0x2f};
static uint8_t f_warning[] = {0xa5,0x03,0x00,0x37,0x1a,0x04,0x01,0x07,0x14,0x21,0x40,0xdd};
static uint8_t short_warning[] = {0xa5,0x02,0x00,0x37,0xb1,0x04,0x01,0x07,0x14,0xdd,0xb9};
static uint8_t long_warning[] = {0xa5,0x04,0x00,0x37,0x60,0x04,0x01,0x07,0x14,0x21,0x00,0x37,0x7e};
static uint8_t f_dart[] = {0xa5,0x03,0x00,0x37,0x1a,0x05,0x01,0x07,0x14,0x21,0x04,0xd6};
static uint8_t short_dart[] = {0xa5,0x02,0x00,0x37,0xb1,0x05,0x01,0x07,0x14,0x66,0xa5};
static uint8_t long_dart[] = {0xa5,0x04,0x00,0x37,0x60,0x05,0x01,0x07,0x14,0x21,0x00,0x1c,0x7a};
static uint8_t f_status[] = {0xa5,0x11,0x00,0x37,0x1f,0x01,0x02,0x6b,0x03,0x20,0x03,0x84,0x03,0x28,0x00,0xf0,0x00,0x78,0x00,0x00,0x00,0xf0,0x41,0x05,0x77,0x72};
static uint8_t short_status[] = {0xa5,0x10,0x00,0x37,0xb4,0x01,0x02,0x6b,0x03,0x20,0x03,0x84,0x03,0x28,0x00,0xf0,0x00,0x78,0x00,0x00,0x00,0xf0,0x41,0x96,0x56};
static uint8_t long_status[] = {0xa5,0x12,0x00,0x37,0xfb,0x01,0x02,0x6b,0x03,0x20,0x03,0x84,0x03,0x28,0x00,0xf0,0x00,0x78,0x00,0x00,0x00,0xf0,0x41,0x05,0x00,0xa6,0x36};
static uint8_t f_heat[] = {0xa5,0x0e,0x00,0x37,0x0a,0x02,0x02,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x78,0x00,0x46,0x00,0x50,0x00,0xea,0x7d};
static uint8_t short_heat[] = {0xa5,0x0d,0x00,0x37,0xee,0x02,0x02,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x78,0x00,0x46,0x00,0x50,0x20,0x71};
static uint8_t long_heat[] = {0xa5,0x0f,0x00,0x37,0xa1,0x02,0x02,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x78,0x00,0x46,0x00,0x50,0x00,0x00,0x32,0xe8};
static uint8_t f_pos[] = {0xa5,0x0c,0x00,0x37,0x45,0x03,0x02,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0xac,0x72};
static uint8_t short_pos[] = {0xa5,0x0b,0x00,0x37,0x3f,0x03,0x02,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x6a,0x71};
static uint8_t long_pos[] = {0xa5,0x0d,0x00,0x37,0xee,0x03,0x02,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0x00,0xac,0x59};
static uint8_t f_buff[] = {0xa5,0x07,0x00,0x37,0x84,0x04,0x02,0x0a,0x45,0x03,0x32,0x1e,0x96,0x00,0x67,0xba};
static uint8_t short_buff[] = {0xa5,0x06,0x00,0x37,0x2f,0x04,0x02,0x0a,0x45,0x03,0x32,0x1e,0x96,0x39,0x8b};
static uint8_t long_buff[] = {0xa5,0x08,0x00,0x37,0xdb,0x04,0x02,0x0a,0x45,0x03,0x32,0x1e,0x96,0x00,0x00,0xeb,0x28};
static uint8_t f_hurt[] = {0xa5,0x07,0x00,0x37,0x84,0x06,0x02,0x53,0x34,0x12,0xe9,0xff,0x42,0x00,0x0e,0x3f};
static uint8_t short_hurt[] = {0xa5,0x06,0x00,0x37,0x2f,0x06,0x02,0x53,0x34,0x12,0xe9,0xff,0x42,0xa8,0xe2};
static uint8_t long_hurt[] = {0xa5,0x08,0x00,0x37,0xdb,0x06,0x02,0x53,0x34,0x12,0xe9,0xff,0x42,0x00,0x00,0xa9,0xd6};
static uint8_t f_shoot[] = {0xa5,0x07,0x00,0x37,0x84,0x07,0x02,0x01,0x01,0x0a,0x00,0x00,0xbc,0x41,0x3f,0x34};
static uint8_t short_shoot[] = {0xa5,0x06,0x00,0x37,0x2f,0x07,0x02,0x01,0x01,0x0a,0x00,0x00,0xbc,0x52,0x8b};
static uint8_t long_shoot[] = {0xa5,0x08,0x00,0x37,0xdb,0x07,0x02,0x01,0x01,0x0a,0x00,0x00,0xbc,0x41,0x00,0xa8,0xf6};
static uint8_t f_ammo[] = {0xa5,0x08,0x00,0x37,0xdb,0x08,0x02,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x94,0x7b};
static uint8_t short_ammo[] = {0xa5,0x07,0x00,0x37,0x84,0x08,0x02,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x44,0x48};
static uint8_t long_ammo[] = {0xa5,0x09,0x00,0x37,0x70,0x08,0x02,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x00,0x8e,0x92};
static uint8_t f_rfid[] = {0xa5,0x06,0x00,0x37,0x2f,0x09,0x02,0x07,0x14,0x21,0x2e,0x3b,0x48,0x76,0x8e};
static uint8_t short_rfid[] = {0xa5,0x05,0x00,0x37,0xcb,0x09,0x02,0x07,0x14,0x21,0x2e,0x3b,0xec,0xde};
static uint8_t long_rfid[] = {0xa5,0x07,0x00,0x37,0x84,0x09,0x02,0x07,0x14,0x21,0x2e,0x3b,0x48,0x00,0x91,0x00};
static uint8_t f_dart_client[] = {0xa5,0x06,0x00,0x37,0x2f,0x0a,0x02,0x07,0x14,0x21,0x2e,0x3b,0x48,0xa6,0x04};
static uint8_t short_dart_client[] = {0xa5,0x05,0x00,0x37,0xcb,0x0a,0x02,0x07,0x14,0x21,0x2e,0x3b,0x82,0x76};
static uint8_t long_dart_client[] = {0xa5,0x07,0x00,0x37,0x84,0x0a,0x02,0x07,0x14,0x21,0x2e,0x3b,0x48,0x00,0x96,0xd6};
static uint8_t f_ground[] = {0xa5,0x28,0x00,0x37,0x4f,0x0b,0x02,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0xa3,0xb0,0xbd,0xca,0xd7,0xe4,0xf1,0xfe,0x0b,0x18,0x25,0x32,0x3f,0x4c,0x59,0x66,0x73,0x80,0x8d,0x9a,0xa7,0xb4,0xc1,0xce,0xdb,0xe8,0xf5,0x02,0x0d,0xab};
static uint8_t short_ground[] = {0xa5,0x27,0x00,0x37,0x10,0x0b,0x02,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0xa3,0xb0,0xbd,0xca,0xd7,0xe4,0xf1,0xfe,0x0b,0x18,0x25,0x32,0x3f,0x4c,0x59,0x66,0x73,0x80,0x8d,0x9a,0xa7,0xb4,0xc1,0xce,0xdb,0xe8,0xf5,0xb5,0x9f};
static uint8_t long_ground[] = {0xa5,0x29,0x00,0x37,0xe4,0x0b,0x02,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0xa3,0xb0,0xbd,0xca,0xd7,0xe4,0xf1,0xfe,0x0b,0x18,0x25,0x32,0x3f,0x4c,0x59,0x66,0x73,0x80,0x8d,0x9a,0xa7,0xb4,0xc1,0xce,0xdb,0xe8,0xf5,0x02,0x00,0x47,0xc9};
static uint8_t f_mark[] = {0xa5,0x02,0x00,0x37,0xb1,0x0c,0x02,0x07,0x14,0x61,0xb3};
static uint8_t short_mark[] = {0xa5,0x01,0x00,0x37,0x55,0x0c,0x02,0x07,0xca,0xb4};
static uint8_t long_mark[] = {0xa5,0x03,0x00,0x37,0x1a,0x0c,0x02,0x07,0x14,0x00,0x26,0x92};
static uint8_t f_sentry[] = {0xa5,0x0e,0x00,0x37,0x0a,0x0d,0x02,0x7b,0x18,0x9a,0x3e,0xd1,0xe7,0x0a,0x14,0x1e,0xa5,0x28,0x32,0x3c,0x5a,0x68,0x76};
static uint8_t short_sentry[] = {0xa5,0x0d,0x00,0x37,0xee,0x0d,0x02,0x7b,0x18,0x9a,0x3e,0xd1,0xe7,0x0a,0x14,0x1e,0xa5,0x28,0x32,0x3c,0xc1,0xab};
static uint8_t long_sentry[] = {0xa5,0x0f,0x00,0x37,0xa1,0x0d,0x02,0x7b,0x18,0x9a,0x3e,0xd1,0xe7,0x0a,0x14,0x1e,0xa5,0x28,0x32,0x3c,0x5a,0x00,0x23,0x4f};
static uint8_t f_radar[] = {0xa5,0x08,0x00,0x37,0xdb,0x0e,0x02,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x46,0x93};
static uint8_t short_radar[] = {0xa5,0x07,0x00,0x37,0x84,0x0e,0x02,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x5b,0xec};
static uint8_t long_radar[] = {0xa5,0x09,0x00,0x37,0x70,0x0e,0x02,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x00,0xf9,0x67};
static uint8_t f_map_cmd[] = {0xa5,0x0c,0x00,0x37,0x45,0x03,0x03,0x00,0x00,0xa0,0x3f,0x00,0x00,0x20,0xc0,0x41,0x67,0x67,0x01,0x68,0x86};
static uint8_t short_map_cmd[] = {0xa5,0x0b,0x00,0x37,0x3f,0x03,0x03,0x00,0x00,0xa0,0x3f,0x00,0x00,0x20,0xc0,0x41,0x67,0x67,0x3e,0x22};
static uint8_t long_map_cmd[] = {0xa5,0x0d,0x00,0x37,0xee,0x03,0x03,0x00,0x00,0xa0,0x3f,0x00,0x00,0x20,0xc0,0x41,0x67,0x67,0x01,0x00,0x70,0xd9};
static uint8_t f_map_robot[] = {0xa5,0x30,0x00,0x37,0x20,0x05,0x03,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0xa3,0xb0,0xbd,0xca,0xd7,0xe4,0xf1,0xfe,0x0b,0x18,0x25,0x32,0x3f,0x4c,0x59,0x66,0x73,0x80,0x8d,0x9a,0xa7,0xb4,0xc1,0xce,0xdb,0xe8,0xf5,0x02,0x0f,0x1c,0x29,0x36,0x43,0x50,0x5d,0x6a,0xeb,0xb1};
static uint8_t short_map_robot[] = {0xa5,0x2f,0x00,0x37,0x35,0x05,0x03,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0xa3,0xb0,0xbd,0xca,0xd7,0xe4,0xf1,0xfe,0x0b,0x18,0x25,0x32,0x3f,0x4c,0x59,0x66,0x73,0x80,0x8d,0x9a,0xa7,0xb4,0xc1,0xce,0xdb,0xe8,0xf5,0x02,0x0f,0x1c,0x29,0x36,0x43,0x50,0x5d,0xfd,0xe0};
static uint8_t long_map_robot[] = {0xa5,0x31,0x00,0x37,0x8b,0x05,0x03,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0xa3,0xb0,0xbd,0xca,0xd7,0xe4,0xf1,0xfe,0x0b,0x18,0x25,0x32,0x3f,0x4c,0x59,0x66,0x73,0x80,0x8d,0x9a,0xa7,0xb4,0xc1,0xce,0xdb,0xe8,0xf5,0x02,0x0f,0x1c,0x29,0x36,0x43,0x50,0x5d,0x6a,0x00,0x1d,0x77};
static uint8_t f_path[] = {0xa5,0x69,0x00,0x37,0xd5,0x07,0x03,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0xa3,0xb0,0xbd,0xca,0xd7,0xe4,0xf1,0xfe,0x0b,0x18,0x25,0x32,0x3f,0x4c,0x59,0x66,0x73,0x80,0x8d,0x9a,0xa7,0xb4,0xc1,0xce,0xdb,0xe8,0xf5,0x02,0x0f,0x1c,0x29,0x36,0x43,0x50,0x5d,0x6a,0x77,0x84,0x91,0x9e,0xab,0xb8,0xc5,0xd2,0xdf,0xec,0xf9,0x06,0x13,0x20,0x2d,0x3a,0x47,0x54,0x61,0x6e,0x7b,0x88,0x95,0xa2,0xaf,0xbc,0xc9,0xd6,0xe3,0xf0,0xfd,0x0a,0x17,0x24,0x31,0x3e,0x4b,0x58,0x65,0x72,0x7f,0x8c,0x99,0xa6,0xb3,0xc0,0xcd,0xda,0xe7,0xf4,0x01,0x0e,0x1b,0x28,0x35,0x42,0x4f,0xd2,0x11};
static uint8_t short_path[] = {0xa5,0x68,0x00,0x37,0x7e,0x07,0x03,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0xa3,0xb0,0xbd,0xca,0xd7,0xe4,0xf1,0xfe,0x0b,0x18,0x25,0x32,0x3f,0x4c,0x59,0x66,0x73,0x80,0x8d,0x9a,0xa7,0xb4,0xc1,0xce,0xdb,0xe8,0xf5,0x02,0x0f,0x1c,0x29,0x36,0x43,0x50,0x5d,0x6a,0x77,0x84,0x91,0x9e,0xab,0xb8,0xc5,0xd2,0xdf,0xec,0xf9,0x06,0x13,0x20,0x2d,0x3a,0x47,0x54,0x61,0x6e,0x7b,0x88,0x95,0xa2,0xaf,0xbc,0xc9,0xd6,0xe3,0xf0,0xfd,0x0a,0x17,0x24,0x31,0x3e,0x4b,0x58,0x65,0x72,0x7f,0x8c,0x99,0xa6,0xb3,0xc0,0xcd,0xda,0xe7,0xf4,0x01,0x0e,0x1b,0x28,0x35,0x42,0x1b,0x76};
static uint8_t long_path[] = {0xa5,0x6a,0x00,0x37,0x31,0x07,0x03,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0xa3,0xb0,0xbd,0xca,0xd7,0xe4,0xf1,0xfe,0x0b,0x18,0x25,0x32,0x3f,0x4c,0x59,0x66,0x73,0x80,0x8d,0x9a,0xa7,0xb4,0xc1,0xce,0xdb,0xe8,0xf5,0x02,0x0f,0x1c,0x29,0x36,0x43,0x50,0x5d,0x6a,0x77,0x84,0x91,0x9e,0xab,0xb8,0xc5,0xd2,0xdf,0xec,0xf9,0x06,0x13,0x20,0x2d,0x3a,0x47,0x54,0x61,0x6e,0x7b,0x88,0x95,0xa2,0xaf,0xbc,0xc9,0xd6,0xe3,0xf0,0xfd,0x0a,0x17,0x24,0x31,0x3e,0x4b,0x58,0x65,0x72,0x7f,0x8c,0x99,0xa6,0xb3,0xc0,0xcd,0xda,0xe7,0xf4,0x01,0x0e,0x1b,0x28,0x35,0x42,0x4f,0x00,0x65,0x93};
static uint8_t f_custom_info[] = {0xa5,0x22,0x00,0x37,0x25,0x08,0x03,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0xa3,0xb0,0xbd,0xca,0xd7,0xe4,0xf1,0xfe,0x0b,0x18,0x25,0x32,0x3f,0x4c,0x59,0x66,0x73,0x80,0x8d,0x9a,0xa7,0xb4,0x8e,0xb1};
static uint8_t short_custom_info[] = {0xa5,0x21,0x00,0x37,0xc1,0x08,0x03,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0xa3,0xb0,0xbd,0xca,0xd7,0xe4,0xf1,0xfe,0x0b,0x18,0x25,0x32,0x3f,0x4c,0x59,0x66,0x73,0x80,0x8d,0x9a,0xa7,0x17,0xb8};
static uint8_t long_custom_info[] = {0xa5,0x23,0x00,0x37,0x8e,0x08,0x03,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0xa3,0xb0,0xbd,0xca,0xd7,0xe4,0xf1,0xfe,0x0b,0x18,0x25,0x32,0x3f,0x4c,0x59,0x66,0x73,0x80,0x8d,0x9a,0xa7,0xb4,0x00,0x2e,0x53};
static uint8_t f_custom_tx[] = {0xa5,0x2c,0x01,0x37,0x15,0x10,0x03,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0xa3,0xb0,0xbd,0xca,0xd7,0xe4,0xf1,0xfe,0x0b,0x18,0x25,0x32,0x3f,0x4c,0x59,0x66,0x73,0x80,0x8d,0x9a,0xa7,0xb4,0xc1,0xce,0xdb,0xe8,0xf5,0x02,0x0f,0x1c,0x29,0x36,0x43,0x50,0x5d,0x6a,0x77,0x84,0x91,0x9e,0xab,0xb8,0xc5,0xd2,0xdf,0xec,0xf9,0x06,0x13,0x20,0x2d,0x3a,0x47,0x54,0x61,0x6e,0x7b,0x88,0x95,0xa2,0xaf,0xbc,0xc9,0xd6,0xe3,0xf0,0xfd,0x0a,0x17,0x24,0x31,0x3e,0x4b,0x58,0x65,0x72,0x7f,0x8c,0x99,0xa6,0xb3,0xc0,0xcd,0xda,0xe7,0xf4,0x01,0x0e,0x1b,0x28,0x35,0x42,0x4f,0x5c,0x69,0x76,0x83,0x90,0x9d,0xaa,0xb7,0xc4,0xd1,0xde,0xeb,0xf8,0x05,0x12,0x1f,0x2c,0x39,0x46,0x53,0x60,0x6d,0x7a,0x87,0x94,0xa1,0xae,0xbb,0xc8,0xd5,0xe2,0xef,0xfc,0x09,0x16,0x23,0x30,0x3d,0x4a,0x57,0x64,0x71,0x7e,0x8b,0x98,0xa5,0xb2,0xbf,0xcc,0xd9,0xe6,0xf3,0x00,0x0d,0x1a,0x27,0x34,0x41,0x4e,0x5b,0x68,0x75,0x82,0x8f,0x9c,0xa9,0xb6,0xc3,0xd0,0xdd,0xea,0xf7,0x04,0x11,0x1e,0x2b,0x38,0x45,0x52,0x5f,0x6c,0x79,0x86,0x93,0xa0,0xad,0xba,0xc7,0xd4,0xe1,0xee,0xfb,0x08,0x15,0x22,0x2f,0x3c,0x49,0x56,0x63,0x70,0x7d,0x8a,0x97,0xa4,0xb1,0xbe,0xcb,0xd8,0xe5,0xf2,0xff,0x0c,0x19,0x26,0x33,0x40,0x4d,0x5a,0x67,0x74,0x81,0x8e,0x9b,0xa8,0xb5,0xc2,0xcf,0xdc,0xe9,0xf6,0x03,0x10,0x1d,0x2a,0x37,0x44,0x51,0x5e,0x6b,0x78,0x85,0x92,0x9f,0xac,0xb9,0xc6,0xd3,0xe0,0xed,0xfa,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0xa3,0xb0,0xbd,0xca,0xd7,0xe4,0xf1,0xfe,0x0b,0x18,0x25,0x32,0x3f,0x4c,0x59,0x66,0x73,0x80,0x8d,0x9a,0xa7,0xb4,0xc1,0xce,0xdb,0xe8,0xf5,0x02,0x0f,0x1c,0x29,0x36,0x5f,0x9e};
static uint8_t short_custom_tx[] = {0xa5,0x2b,0x01,0x37,0x6f,0x10,0x03,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0xa3,0xb0,0xbd,0xca,0xd7,0xe4,0xf1,0xfe,0x0b,0x18,0x25,0x32,0x3f,0x4c,0x59,0x66,0x73,0x80,0x8d,0x9a,0xa7,0xb4,0xc1,0xce,0xdb,0xe8,0xf5,0x02,0x0f,0x1c,0x29,0x36,0x43,0x50,0x5d,0x6a,0x77,0x84,0x91,0x9e,0xab,0xb8,0xc5,0xd2,0xdf,0xec,0xf9,0x06,0x13,0x20,0x2d,0x3a,0x47,0x54,0x61,0x6e,0x7b,0x88,0x95,0xa2,0xaf,0xbc,0xc9,0xd6,0xe3,0xf0,0xfd,0x0a,0x17,0x24,0x31,0x3e,0x4b,0x58,0x65,0x72,0x7f,0x8c,0x99,0xa6,0xb3,0xc0,0xcd,0xda,0xe7,0xf4,0x01,0x0e,0x1b,0x28,0x35,0x42,0x4f,0x5c,0x69,0x76,0x83,0x90,0x9d,0xaa,0xb7,0xc4,0xd1,0xde,0xeb,0xf8,0x05,0x12,0x1f,0x2c,0x39,0x46,0x53,0x60,0x6d,0x7a,0x87,0x94,0xa1,0xae,0xbb,0xc8,0xd5,0xe2,0xef,0xfc,0x09,0x16,0x23,0x30,0x3d,0x4a,0x57,0x64,0x71,0x7e,0x8b,0x98,0xa5,0xb2,0xbf,0xcc,0xd9,0xe6,0xf3,0x00,0x0d,0x1a,0x27,0x34,0x41,0x4e,0x5b,0x68,0x75,0x82,0x8f,0x9c,0xa9,0xb6,0xc3,0xd0,0xdd,0xea,0xf7,0x04,0x11,0x1e,0x2b,0x38,0x45,0x52,0x5f,0x6c,0x79,0x86,0x93,0xa0,0xad,0xba,0xc7,0xd4,0xe1,0xee,0xfb,0x08,0x15,0x22,0x2f,0x3c,0x49,0x56,0x63,0x70,0x7d,0x8a,0x97,0xa4,0xb1,0xbe,0xcb,0xd8,0xe5,0xf2,0xff,0x0c,0x19,0x26,0x33,0x40,0x4d,0x5a,0x67,0x74,0x81,0x8e,0x9b,0xa8,0xb5,0xc2,0xcf,0xdc,0xe9,0xf6,0x03,0x10,0x1d,0x2a,0x37,0x44,0x51,0x5e,0x6b,0x78,0x85,0x92,0x9f,0xac,0xb9,0xc6,0xd3,0xe0,0xed,0xfa,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0xa3,0xb0,0xbd,0xca,0xd7,0xe4,0xf1,0xfe,0x0b,0x18,0x25,0x32,0x3f,0x4c,0x59,0x66,0x73,0x80,0x8d,0x9a,0xa7,0xb4,0xc1,0xce,0xdb,0xe8,0xf5,0x02,0x0f,0x1c,0x29,0xa4,0x78};
static uint8_t long_custom_tx[] = {0xa5,0x2d,0x01,0x37,0xbe,0x10,0x03,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0xa3,0xb0,0xbd,0xca,0xd7,0xe4,0xf1,0xfe,0x0b,0x18,0x25,0x32,0x3f,0x4c,0x59,0x66,0x73,0x80,0x8d,0x9a,0xa7,0xb4,0xc1,0xce,0xdb,0xe8,0xf5,0x02,0x0f,0x1c,0x29,0x36,0x43,0x50,0x5d,0x6a,0x77,0x84,0x91,0x9e,0xab,0xb8,0xc5,0xd2,0xdf,0xec,0xf9,0x06,0x13,0x20,0x2d,0x3a,0x47,0x54,0x61,0x6e,0x7b,0x88,0x95,0xa2,0xaf,0xbc,0xc9,0xd6,0xe3,0xf0,0xfd,0x0a,0x17,0x24,0x31,0x3e,0x4b,0x58,0x65,0x72,0x7f,0x8c,0x99,0xa6,0xb3,0xc0,0xcd,0xda,0xe7,0xf4,0x01,0x0e,0x1b,0x28,0x35,0x42,0x4f,0x5c,0x69,0x76,0x83,0x90,0x9d,0xaa,0xb7,0xc4,0xd1,0xde,0xeb,0xf8,0x05,0x12,0x1f,0x2c,0x39,0x46,0x53,0x60,0x6d,0x7a,0x87,0x94,0xa1,0xae,0xbb,0xc8,0xd5,0xe2,0xef,0xfc,0x09,0x16,0x23,0x30,0x3d,0x4a,0x57,0x64,0x71,0x7e,0x8b,0x98,0xa5,0xb2,0xbf,0xcc,0xd9,0xe6,0xf3,0x00,0x0d,0x1a,0x27,0x34,0x41,0x4e,0x5b,0x68,0x75,0x82,0x8f,0x9c,0xa9,0xb6,0xc3,0xd0,0xdd,0xea,0xf7,0x04,0x11,0x1e,0x2b,0x38,0x45,0x52,0x5f,0x6c,0x79,0x86,0x93,0xa0,0xad,0xba,0xc7,0xd4,0xe1,0xee,0xfb,0x08,0x15,0x22,0x2f,0x3c,0x49,0x56,0x63,0x70,0x7d,0x8a,0x97,0xa4,0xb1,0xbe,0xcb,0xd8,0xe5,0xf2,0xff,0x0c,0x19,0x26,0x33,0x40,0x4d,0x5a,0x67,0x74,0x81,0x8e,0x9b,0xa8,0xb5,0xc2,0xcf,0xdc,0xe9,0xf6,0x03,0x10,0x1d,0x2a,0x37,0x44,0x51,0x5e,0x6b,0x78,0x85,0x92,0x9f,0xac,0xb9,0xc6,0xd3,0xe0,0xed,0xfa,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0xa3,0xb0,0xbd,0xca,0xd7,0xe4,0xf1,0xfe,0x0b,0x18,0x25,0x32,0x3f,0x4c,0x59,0x66,0x73,0x80,0x8d,0x9a,0xa7,0xb4,0xc1,0xce,0xdb,0xe8,0xf5,0x02,0x0f,0x1c,0x29,0x36,0x00,0xb6,0xe1};
static uint8_t f_custom_rx[] = {0xa5,0x3c,0x00,0x37,0x9b,0x11,0x03,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0xa3,0xb0,0xbd,0xca,0xd7,0xe4,0xf1,0xfe,0x0b,0x18,0x25,0x32,0x3f,0x4c,0x59,0x66,0x73,0x80,0x8d,0x9a,0xa7,0xb4,0xc1,0xce,0xdb,0xe8,0xf5,0x02,0x0f,0x1c,0x29,0x36,0x43,0x50,0x5d,0x6a,0x77,0x84,0x91,0x9e,0xab,0xb8,0xc5,0xd2,0xdf,0xec,0xf9,0x06,0x7c,0x99};
static uint8_t short_custom_rx[] = {0xa5,0x3b,0x00,0x37,0xe1,0x11,0x03,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0xa3,0xb0,0xbd,0xca,0xd7,0xe4,0xf1,0xfe,0x0b,0x18,0x25,0x32,0x3f,0x4c,0x59,0x66,0x73,0x80,0x8d,0x9a,0xa7,0xb4,0xc1,0xce,0xdb,0xe8,0xf5,0x02,0x0f,0x1c,0x29,0x36,0x43,0x50,0x5d,0x6a,0x77,0x84,0x91,0x9e,0xab,0xb8,0xc5,0xd2,0xdf,0xec,0xf9,0xd6,0x27};
static uint8_t long_custom_rx[] = {0xa5,0x3d,0x00,0x37,0x30,0x11,0x03,0x07,0x14,0x21,0x2e,0x3b,0x48,0x55,0x62,0x6f,0x7c,0x89,0x96,0xa3,0xb0,0xbd,0xca,0xd7,0xe4,0xf1,0xfe,0x0b,0x18,0x25,0x32,0x3f,0x4c,0x59,0x66,0x73,0x80,0x8d,0x9a,0xa7,0xb4,0xc1,0xce,0xdb,0xe8,0xf5,0x02,0x0f,0x1c,0x29,0x36,0x43,0x50,0x5d,0x6a,0x77,0x84,0x91,0x9e,0xab,0xb8,0xc5,0xd2,0xdf,0xec,0xf9,0x06,0x00,0x78,0xfe};
static uint8_t sub_100[] = {0xa5,0x08,0x00,0x37,0xdb,0x01,0x03,0x00,0x01,0x03,0x00,0x03,0x01,0x33,0x33,0xd7,0x67};
static uint8_t sub_bad_100[] = {0xa5,0x07,0x00,0x37,0x84,0x01,0x03,0x00,0x01,0x03,0x00,0x03,0x01,0x33,0xc9,0xea};
static uint8_t sub_101[] = {0xa5,0x15,0x00,0x37,0x81,0x01,0x03,0x01,0x01,0x03,0x00,0x03,0x01,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0xd1,0x56};
static uint8_t sub_bad_101[] = {0xa5,0x14,0x00,0x37,0x2a,0x01,0x03,0x01,0x01,0x03,0x00,0x03,0x01,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0xb6,0x25};
static uint8_t sub_102[] = {0xa5,0x24,0x00,0x37,0xf4,0x01,0x03,0x02,0x01,0x03,0x00,0x03,0x01,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0xa1,0x7f};
static uint8_t sub_bad_102[] = {0xa5,0x23,0x00,0x37,0x8e,0x01,0x03,0x02,0x01,0x03,0x00,0x03,0x01,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0xf9,0x41};
static uint8_t sub_103[] = {0xa5,0x51,0x00,0x37,0x2e,0x01,0x03,0x03,0x01,0x03,0x00,0x03,0x01,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0xd1,0xab};
static uint8_t sub_bad_103[] = {0xa5,0x50,0x00,0x37,0x85,0x01,0x03,0x03,0x01,0x03,0x00,0x03,0x01,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x6a,0x07};
static uint8_t sub_104[] = {0xa5,0x6f,0x00,0x37,0x04,0x01,0x03,0x04,0x01,0x03,0x00,0x03,0x01,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x99,0xa6};
static uint8_t sub_bad_104[] = {0xa5,0x6e,0x00,0x37,0xaf,0x01,0x03,0x04,0x01,0x03,0x00,0x03,0x01,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0xa3,0xc3};
static uint8_t sub_110[] = {0xa5,0x33,0x00,0x37,0xc4,0x01,0x03,0x10,0x01,0x03,0x00,0x03,0x01,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0xd4,0x2d};
static uint8_t sub_bad_110[] = {0xa5,0x32,0x00,0x37,0x6f,0x01,0x03,0x10,0x01,0x03,0x00,0x03,0x01,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0xff,0xd4};
static uint8_t sub_120[] = {0xa5,0x0a,0x00,0x37,0x94,0x01,0x03,0x20,0x01,0x03,0x00,0x03,0x01,0x33,0x33,0x33,0x33,0xa6,0x74};
static uint8_t sub_bad_120[] = {0xa5,0x09,0x00,0x37,0x70,0x01,0x03,0x20,0x01,0x03,0x00,0x03,0x01,0x33,0x33,0x33,0x2c,0x16};
static uint8_t sub_121[] = {0xa5,0x13,0x00,0x37,0x50,0x01,0x03,0x21,0x01,0x03,0x00,0x03,0x01,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x76,0x03};
static uint8_t sub_bad_121[] = {0xa5,0x12,0x00,0x37,0xfb,0x01,0x03,0x21,0x01,0x03,0x00,0x03,0x01,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,0xcc,0x6d};
static uint8_t interaction_0[] = {0xa5,0x06,0x00,0x37,0x2f,0x01,0x03,0x01,0x02,0x03,0x00,0x04,0x00,0x1e,0xf5};
static uint8_t interaction_1[] = {0xa5,0x07,0x00,0x37,0x84,0x01,0x03,0x01,0x02,0x03,0x00,0x04,0x00,0x77,0x9c,0xe8};
static uint8_t interaction_112[] = {0xa5,0x76,0x00,0x37,0xc0,0x01,0x03,0x01,0x02,0x03,0x00,0x04,0x00,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x77,0x3a,0x8e};
static uint8_t interaction_too_long[] = {0xa5,0x77,0x00,0x37,0x6b,0x01,0x03,0x01,0x02,0x03,0x00,0x04,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x3a,0x55};
static uint8_t interaction_unknown[] = {0xa5,0x06,0x00,0x37,0x2f,0x01,0x03,0x34,0x12,0x03,0x00,0x04,0x00,0x09,0x92};
static uint8_t removed_102[] = {0xa5,0x1e,0x00,0x37,0x40,0x02,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xcf,0x88};
static uint8_t removed_103[] = {0xa5,0x1e,0x00,0x37,0x40,0x03,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xad,0xff};
static uint8_t removed_205[] = {0xa5,0x1e,0x00,0x37,0x40,0x05,0x02,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xbd,0x83};
static uint8_t removed_302[] = {0xa5,0x1e,0x00,0x37,0x40,0x02,0x03,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xb6,0x0a};
static uint8_t removed_304[] = {0xa5,0x1e,0x00,0x37,0x40,0x04,0x03,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xeb,0x31};
static uint8_t removed_306[] = {0xa5,0x1e,0x00,0x37,0x40,0x06,0x03,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x2f,0xdf};
static uint8_t removed_309[] = {0xa5,0x1e,0x00,0x37,0x40,0x09,0x03,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x33,0x30};

static unsigned int checks;
#define CHECK(condition) do { ++checks; if (!(condition)) { printf("FAIL line %d: %s\n", __LINE__, #condition); return 1; } } while (0)
static void reset_stream(void) { memset(&referee_unpack_obj, 0, sizeof(referee_unpack_obj)); memset(&referee_fifo, 0, sizeof(referee_fifo)); }
static void feed(const uint8_t *data, unsigned int length) { fifo_s_puts(&referee_fifo, (const char *)data, length); referee_unpack_fifo_data(); }
int main(void) {
    unsigned int split, i, before;
    uint8_t saved[300], bad[320], stream[500];
    sentry_fh sent;
    sentry_info_extracted_t sentry;
    event_data_parsed_t event;
    FILE *capture;
    init_referee_struct_data();
    CHECK(offsetof(robot_status_t, bullet_speed_limit) == 12);
    CHECK(offsetof(buff_t, cooling_buff) == 1 && offsetof(buff_t, attack_buff) == 5);
    CHECK(offsetof(sentry_info_t, sentry_info_3) == 6);
    CHECK(offsetof(rfid_status_t, rfid_status_2) == 4);
    CHECK(offsetof(map_command_t, cmd_source) == 10);


    for (split = 0; split <= sizeof(f_game); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_game, split); feed(f_game + split, sizeof(f_game) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x0001);
        CHECK(referee_last_rx_tick == tick && memcmp(&game_state, f_game + 7, 11) == 0);
    }
    memcpy(saved, &game_state, 11); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_game, sizeof(short_game)) == 0);
    CHECK(referee_data_solve(long_game, sizeof(long_game)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &game_state, 11) == 0);


    for (split = 0; split <= sizeof(f_result); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_result, split); feed(f_result + split, sizeof(f_result) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x0002);
        CHECK(referee_last_rx_tick == tick && memcmp(&game_result, f_result + 7, 1) == 0);
    }
    memcpy(saved, &game_result, 1); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_result, sizeof(short_result)) == 0);
    CHECK(referee_data_solve(long_result, sizeof(long_result)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &game_result, 1) == 0);


    for (split = 0; split <= sizeof(f_hp); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_hp, split); feed(f_hp + split, sizeof(f_hp) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x0003);
        CHECK(referee_last_rx_tick == tick && memcmp(&game_robot_HP, f_hp + 7, 24) == 0);
    }
    memcpy(saved, &game_robot_HP, 24); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_hp, sizeof(short_hp)) == 0);
    CHECK(referee_data_solve(long_hp, sizeof(long_hp)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &game_robot_HP, 24) == 0);


    for (split = 0; split <= sizeof(f_event); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_event, split); feed(f_event + split, sizeof(f_event) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x0101);
        CHECK(referee_last_rx_tick == tick && memcmp(&field_event, f_event + 7, 8) == 0);
    }
    memcpy(saved, &field_event, 8); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_event, sizeof(short_event)) == 0);
    CHECK(referee_data_solve(long_event, sizeof(long_event)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &field_event, 8) == 0);


    for (split = 0; split <= sizeof(f_warning); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_warning, split); feed(f_warning + split, sizeof(f_warning) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x0104);
        CHECK(referee_last_rx_tick == tick && memcmp(&referee_warning, f_warning + 7, 3) == 0);
    }
    memcpy(saved, &referee_warning, 3); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_warning, sizeof(short_warning)) == 0);
    CHECK(referee_data_solve(long_warning, sizeof(long_warning)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &referee_warning, 3) == 0);


    for (split = 0; split <= sizeof(f_dart); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_dart, split); feed(f_dart + split, sizeof(f_dart) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x0105);
        CHECK(referee_last_rx_tick == tick && memcmp(&dart_info, f_dart + 7, 3) == 0);
    }
    memcpy(saved, &dart_info, 3); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_dart, sizeof(short_dart)) == 0);
    CHECK(referee_data_solve(long_dart, sizeof(long_dart)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &dart_info, 3) == 0);


    for (split = 0; split <= sizeof(f_status); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_status, split); feed(f_status + split, sizeof(f_status) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x0201);
        CHECK(referee_last_rx_tick == tick && memcmp(&robot_state, f_status + 7, 17) == 0);
    }
    memcpy(saved, &robot_state, 17); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_status, sizeof(short_status)) == 0);
    CHECK(referee_data_solve(long_status, sizeof(long_status)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &robot_state, 17) == 0);


    for (split = 0; split <= sizeof(f_heat); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_heat, split); feed(f_heat + split, sizeof(f_heat) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x0202);
        CHECK(referee_last_rx_tick == tick && memcmp(&power_heat_data, f_heat + 7, 14) == 0);
    }
    memcpy(saved, &power_heat_data, 14); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_heat, sizeof(short_heat)) == 0);
    CHECK(referee_data_solve(long_heat, sizeof(long_heat)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &power_heat_data, 14) == 0);


    for (split = 0; split <= sizeof(f_pos); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_pos, split); feed(f_pos + split, sizeof(f_pos) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x0203);
        CHECK(referee_last_rx_tick == tick && memcmp(&game_robot_pos, f_pos + 7, 12) == 0);
    }
    memcpy(saved, &game_robot_pos, 12); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_pos, sizeof(short_pos)) == 0);
    CHECK(referee_data_solve(long_pos, sizeof(long_pos)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &game_robot_pos, 12) == 0);


    for (split = 0; split <= sizeof(f_buff); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_buff, split); feed(f_buff + split, sizeof(f_buff) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x0204);
        CHECK(referee_last_rx_tick == tick && memcmp(&buff, f_buff + 7, 7) == 0);
    }
    memcpy(saved, &buff, 7); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_buff, sizeof(short_buff)) == 0);
    CHECK(referee_data_solve(long_buff, sizeof(long_buff)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &buff, 7) == 0);


    for (split = 0; split <= sizeof(f_hurt); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_hurt, split); feed(f_hurt + split, sizeof(f_hurt) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x0206);
        CHECK(referee_last_rx_tick == tick && memcmp(&robot_hurt, f_hurt + 7, 7) == 0);
    }
    memcpy(saved, &robot_hurt, 7); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_hurt, sizeof(short_hurt)) == 0);
    CHECK(referee_data_solve(long_hurt, sizeof(long_hurt)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &robot_hurt, 7) == 0);


    for (split = 0; split <= sizeof(f_shoot); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_shoot, split); feed(f_shoot + split, sizeof(f_shoot) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x0207);
        CHECK(referee_last_rx_tick == tick && memcmp(&shoot_data, f_shoot + 7, 7) == 0);
    }
    memcpy(saved, &shoot_data, 7); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_shoot, sizeof(short_shoot)) == 0);
    CHECK(referee_data_solve(long_shoot, sizeof(long_shoot)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &shoot_data, 7) == 0);


    for (split = 0; split <= sizeof(f_ammo); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_ammo, split); feed(f_ammo + split, sizeof(f_ammo) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x0208);
        CHECK(referee_last_rx_tick == tick && memcmp(&projectile_allowance, f_ammo + 7, 8) == 0);
    }
    memcpy(saved, &projectile_allowance, 8); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_ammo, sizeof(short_ammo)) == 0);
    CHECK(referee_data_solve(long_ammo, sizeof(long_ammo)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &projectile_allowance, 8) == 0);


    for (split = 0; split <= sizeof(f_rfid); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_rfid, split); feed(f_rfid + split, sizeof(f_rfid) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x0209);
        CHECK(referee_last_rx_tick == tick && memcmp(&robot_rfid, f_rfid + 7, 6) == 0);
    }
    memcpy(saved, &robot_rfid, 6); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_rfid, sizeof(short_rfid)) == 0);
    CHECK(referee_data_solve(long_rfid, sizeof(long_rfid)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &robot_rfid, 6) == 0);


    for (split = 0; split <= sizeof(f_dart_client); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_dart_client, split); feed(f_dart_client + split, sizeof(f_dart_client) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x020a);
        CHECK(referee_last_rx_tick == tick && memcmp(&dart_client_cmd, f_dart_client + 7, 6) == 0);
    }
    memcpy(saved, &dart_client_cmd, 6); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_dart_client, sizeof(short_dart_client)) == 0);
    CHECK(referee_data_solve(long_dart_client, sizeof(long_dart_client)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &dart_client_cmd, 6) == 0);


    for (split = 0; split <= sizeof(f_ground); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_ground, split); feed(f_ground + split, sizeof(f_ground) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x020b);
        CHECK(referee_last_rx_tick == tick && memcmp(&ground_robot_position, f_ground + 7, 40) == 0);
    }
    memcpy(saved, &ground_robot_position, 40); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_ground, sizeof(short_ground)) == 0);
    CHECK(referee_data_solve(long_ground, sizeof(long_ground)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &ground_robot_position, 40) == 0);


    for (split = 0; split <= sizeof(f_mark); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_mark, split); feed(f_mark + split, sizeof(f_mark) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x020c);
        CHECK(referee_last_rx_tick == tick && memcmp(&radar_mark_data, f_mark + 7, 2) == 0);
    }
    memcpy(saved, &radar_mark_data, 2); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_mark, sizeof(short_mark)) == 0);
    CHECK(referee_data_solve(long_mark, sizeof(long_mark)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &radar_mark_data, 2) == 0);


    for (split = 0; split <= sizeof(f_sentry); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_sentry, split); feed(f_sentry + split, sizeof(f_sentry) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x020d);
        CHECK(referee_last_rx_tick == tick && memcmp(&SentryInfo, f_sentry + 7, 14) == 0);
    }
    memcpy(saved, &SentryInfo, 14); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_sentry, sizeof(short_sentry)) == 0);
    CHECK(referee_data_solve(long_sentry, sizeof(long_sentry)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &SentryInfo, 14) == 0);


    for (split = 0; split <= sizeof(f_radar); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_radar, split); feed(f_radar + split, sizeof(f_radar) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x020e);
        CHECK(referee_last_rx_tick == tick && memcmp(&RadarInfo, f_radar + 7, 8) == 0);
    }
    memcpy(saved, &RadarInfo, 8); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_radar, sizeof(short_radar)) == 0);
    CHECK(referee_data_solve(long_radar, sizeof(long_radar)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &RadarInfo, 8) == 0);


    for (split = 0; split <= sizeof(f_map_cmd); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_map_cmd, split); feed(f_map_cmd + split, sizeof(f_map_cmd) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x0303);
        CHECK(referee_last_rx_tick == tick && memcmp(&map_command, f_map_cmd + 7, 12) == 0);
    }
    memcpy(saved, &map_command, 12); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_map_cmd, sizeof(short_map_cmd)) == 0);
    CHECK(referee_data_solve(long_map_cmd, sizeof(long_map_cmd)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &map_command, 12) == 0);


    for (split = 0; split <= sizeof(f_map_robot); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_map_robot, split); feed(f_map_robot + split, sizeof(f_map_robot) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x0305);
        CHECK(referee_last_rx_tick == tick && memcmp(&map_robot_data, f_map_robot + 7, 48) == 0);
    }
    memcpy(saved, &map_robot_data, 48); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_map_robot, sizeof(short_map_robot)) == 0);
    CHECK(referee_data_solve(long_map_robot, sizeof(long_map_robot)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &map_robot_data, 48) == 0);


    for (split = 0; split <= sizeof(f_path); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_path, split); feed(f_path + split, sizeof(f_path) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x0307);
        CHECK(referee_last_rx_tick == tick && memcmp(&map_data, f_path + 7, 105) == 0);
    }
    memcpy(saved, &map_data, 105); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_path, sizeof(short_path)) == 0);
    CHECK(referee_data_solve(long_path, sizeof(long_path)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &map_data, 105) == 0);


    for (split = 0; split <= sizeof(f_custom_info); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_custom_info, split); feed(f_custom_info + split, sizeof(f_custom_info) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x0308);
        CHECK(referee_last_rx_tick == tick && memcmp(&custom_info, f_custom_info + 7, 34) == 0);
    }
    memcpy(saved, &custom_info, 34); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_custom_info, sizeof(short_custom_info)) == 0);
    CHECK(referee_data_solve(long_custom_info, sizeof(long_custom_info)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &custom_info, 34) == 0);


    for (split = 0; split <= sizeof(f_custom_tx); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_custom_tx, split); feed(f_custom_tx + split, sizeof(f_custom_tx) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x0310);
        CHECK(referee_last_rx_tick == tick && memcmp(&robot_custom_data_2, f_custom_tx + 7, 300) == 0);
    }
    memcpy(saved, &robot_custom_data_2, 300); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_custom_tx, sizeof(short_custom_tx)) == 0);
    CHECK(referee_data_solve(long_custom_tx, sizeof(long_custom_tx)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &robot_custom_data_2, 300) == 0);


    for (split = 0; split <= sizeof(f_custom_rx); ++split) {
        reset_stream(); before = referee_rx_valid_frames; ++tick;
        feed(f_custom_rx, split); feed(f_custom_rx + split, sizeof(f_custom_rx) - split);
        CHECK(referee_rx_valid_frames == before + 1 && referee_last_cmd_id == 0x0311);
        CHECK(referee_last_rx_tick == tick && memcmp(&robot_custom_data, f_custom_rx + 7, 60) == 0);
    }
    memcpy(saved, &robot_custom_data, 60); before = referee_rx_valid_frames;
    CHECK(referee_data_solve(short_custom_rx, sizeof(short_custom_rx)) == 0);
    CHECK(referee_data_solve(long_custom_rx, sizeof(long_custom_rx)) == 0);
    CHECK(referee_rx_valid_frames == before && memcmp(saved, &robot_custom_data, 60) == 0);


    reset_stream(); before = referee_rx_valid_frames; feed(sub_100, sizeof(sub_100));
    CHECK(referee_rx_valid_frames == before + 1 && robot_interaction_user_data_length == 2);
    CHECK(robot_interaction_data.data_cmd_id == 0x100);
    CHECK(referee_data_solve(sub_bad_100, sizeof(sub_bad_100)) == 0);


    reset_stream(); before = referee_rx_valid_frames; feed(sub_101, sizeof(sub_101));
    CHECK(referee_rx_valid_frames == before + 1 && robot_interaction_user_data_length == 15);
    CHECK(robot_interaction_data.data_cmd_id == 0x101);
    CHECK(referee_data_solve(sub_bad_101, sizeof(sub_bad_101)) == 0);


    reset_stream(); before = referee_rx_valid_frames; feed(sub_102, sizeof(sub_102));
    CHECK(referee_rx_valid_frames == before + 1 && robot_interaction_user_data_length == 30);
    CHECK(robot_interaction_data.data_cmd_id == 0x102);
    CHECK(referee_data_solve(sub_bad_102, sizeof(sub_bad_102)) == 0);


    reset_stream(); before = referee_rx_valid_frames; feed(sub_103, sizeof(sub_103));
    CHECK(referee_rx_valid_frames == before + 1 && robot_interaction_user_data_length == 75);
    CHECK(robot_interaction_data.data_cmd_id == 0x103);
    CHECK(referee_data_solve(sub_bad_103, sizeof(sub_bad_103)) == 0);


    reset_stream(); before = referee_rx_valid_frames; feed(sub_104, sizeof(sub_104));
    CHECK(referee_rx_valid_frames == before + 1 && robot_interaction_user_data_length == 105);
    CHECK(robot_interaction_data.data_cmd_id == 0x104);
    CHECK(referee_data_solve(sub_bad_104, sizeof(sub_bad_104)) == 0);


    reset_stream(); before = referee_rx_valid_frames; feed(sub_110, sizeof(sub_110));
    CHECK(referee_rx_valid_frames == before + 1 && robot_interaction_user_data_length == 45);
    CHECK(robot_interaction_data.data_cmd_id == 0x110);
    CHECK(referee_data_solve(sub_bad_110, sizeof(sub_bad_110)) == 0);


    reset_stream(); before = referee_rx_valid_frames; feed(sub_120, sizeof(sub_120));
    CHECK(referee_rx_valid_frames == before + 1 && robot_interaction_user_data_length == 4);
    CHECK(robot_interaction_data.data_cmd_id == 0x120);
    CHECK(referee_data_solve(sub_bad_120, sizeof(sub_bad_120)) == 0);


    reset_stream(); before = referee_rx_valid_frames; feed(sub_121, sizeof(sub_121));
    CHECK(referee_rx_valid_frames == before + 1 && robot_interaction_user_data_length == 13);
    CHECK(robot_interaction_data.data_cmd_id == 0x121);
    CHECK(referee_data_solve(sub_bad_121, sizeof(sub_bad_121)) == 0);

    CHECK(referee_data_solve(removed_102, sizeof(removed_102)) == 0);
    CHECK(referee_data_solve(removed_103, sizeof(removed_103)) == 0);
    CHECK(referee_data_solve(removed_205, sizeof(removed_205)) == 0);
    CHECK(referee_data_solve(removed_302, sizeof(removed_302)) == 0);
    CHECK(referee_data_solve(removed_304, sizeof(removed_304)) == 0);
    CHECK(referee_data_solve(removed_306, sizeof(removed_306)) == 0);
    CHECK(referee_data_solve(removed_309, sizeof(removed_309)) == 0);

    CHECK(game_robot_HP.damage_difference == -321 && game_robot_HP.outpost_B_HP == 1100);
    CHECK(game_robot_HP.ally_control_degree == 42 && game_robot_HP.enemy_control_degree == 43);
    CHECK(robot_state.bullet_speed_limit == 30.0f && robot_state.current_HP == 800);
    CHECK(robot_state.power_management_gimbal_output == 1 && robot_state.power_management_chassis_output == 0 && robot_state.power_management_shooter_output == 1);
    CHECK(buff.cooling_buff == 0x345 && buff.defence_buff == 50 && buff.attack_buff == 150);
    CHECK(robot_hurt.armor_id == 3 && robot_hurt.HP_deduction_reason == 5 && robot_hurt.hit_sequence == 0x1234);
    CHECK(robot_hurt.hit_position_x == -23 && robot_hurt.hit_position_y == 66);
    CHECK(map_command.cmd_source == 0x0167 && map_command.target_position_y == -2.5f);
    CHECK(get_robot_remain_HP() == 800 && get_robot_max_HP() == 900);
    CHECK(get_chassis_buffer_energy() == 120 && Chassis_Power_Limit() == 120);
    CHECK(get_shooter_cooling_value() == 40 && get_shooter_heat_limit() == 240);
    CHECK(get_shooter_17mm_heat() == 70 && get_shooter_42mm_heat() == 80);
    CHECK(get_bullet_initial_speed() == 23.5f && get_bullet_launching_frequency() == 10 && get_bullet_speed_limit() == 30.0f);

    /* Restore sentry fixture after the sub-ID decoding tests. */
    CHECK(referee_data_solve(f_sentry, sizeof(f_sentry)) == 1);
    get_sentry_info(&sentry);
    CHECK(sentry.exchanged_bullets == 123 && sentry.remote_bullet_cnt == 3 && sentry.remote_heal_cnt == 4);
    CHECK(sentry.can_free_respawn == 1 && sentry.can_pay_respawn == 1 && sentry.respawn_gold_cost == 500);
    CHECK(sentry.current_posture == 2 && sentry.is_enhanced_posture == 1 && sentry.can_activate_rune == 1);
    CHECK(sentry.team_17mm_remaining == 1000 && sentry.is_out_of_combat == 1);
    CHECK(sentry.attack_remaining_time == 10 && sentry.defend_remaining_time == 20 && sentry.move_remaining_time == 30);
    CHECK(sentry.enhanced_attack_remaining_time == 40 && sentry.enhanced_defend_remaining_time == 50 && sentry.enhanced_move_remaining_time == 60);
    get_event_info(&event);

    CHECK(event.supply_zone_activated == 1);
    CHECK(event.small_rune_status == 2);
    CHECK(event.big_rune_status == 1);
    CHECK(event.r_fortress_gain == 4);
    CHECK(event.b_fortress_gain == 3);
    CHECK(event.r_base_gain == 2);
    CHECK(event.b_base_gain == 1);
    CHECK(event.allied_high_ground_gain == 1);
    CHECK(event.r_central_highland_gain == 2);
    CHECK(event.b_central_highland_gain == 3);
    CHECK(event.r_outpost_gain == 4);
    CHECK(event.b_outpost_gain == 2);
    CHECK(event.r_outpost_control == 1);
    CHECK(event.b_outpost_control == 2);
    CHECK(event.r_base_control == 1);
    CHECK(event.b_base_control == 2);
    CHECK(event.enemy_dart_last_hit_time == 420);
    CHECK(event.enemy_dart_last_hit_target == 6);
    CHECK(event.r_highland_activation == 3);
    CHECK(event.r_highland_control == 2);
    CHECK(event.b_highland_activation == 1);
    CHECK(event.b_highland_control == 2);
    CHECK(event.central_activation == 3);
    CHECK(event.central_control == 1);

    /* Packet limits and clearing tails of variable-length interaction data. */
    CHECK(referee_data_solve(interaction_112, sizeof(interaction_112)) == 1);
    CHECK(robot_interaction_user_data_length == 112 && robot_interaction_data.user_data[111] == 0x77);
    CHECK(referee_data_solve(interaction_1, sizeof(interaction_1)) == 1);
    for (i = 1; i < 112; ++i) CHECK(robot_interaction_data.user_data[i] == 0);
    CHECK(referee_data_solve(interaction_0, sizeof(interaction_0)) == 1 && robot_interaction_user_data_length == 0);
    CHECK(referee_data_solve(interaction_too_long, sizeof(interaction_too_long)) == 0);
    CHECK(referee_data_solve(interaction_unknown, sizeof(interaction_unknown)) == 0);

    memcpy(bad, f_status, sizeof(f_status)); bad[7] ^= 1;
    before = referee_rx_valid_frames;
    CHECK(referee_data_solve(bad, sizeof(f_status)) == 0 && referee_rx_valid_frames == before);
    memcpy(bad, f_status, sizeof(f_status)); bad[4] ^= 1;
    CHECK(referee_data_solve(bad, sizeof(f_status)) == 0 && referee_rx_valid_frames == before);
    CHECK(referee_data_solve(f_status, sizeof(f_status) - 1) == 0);
    CHECK(referee_data_solve(NULL, 0) == 0 && referee_data_solve(f_status, 4) == 0);
    /* Noise, a bad packet, a following good packet, and glued packets. */
    reset_stream(); memset(stream, 0xFF, 20); memcpy(stream + 20, bad, sizeof(f_status));
    memcpy(stream + 20 + sizeof(f_status), f_status, sizeof(f_status));
    before = referee_rx_valid_frames; feed(stream, 20 + 2 * sizeof(f_status));
    CHECK(referee_rx_valid_frames == before + 1);
    reset_stream(); memcpy(stream, f_status, sizeof(f_status)); memcpy(stream + sizeof(f_status), f_hp, sizeof(f_hp));
    before = referee_rx_valid_frames; feed(stream, sizeof(f_status) + sizeof(f_hp));
    CHECK(referee_rx_valid_frames == before + 2);
    reset_stream(); stream[0] = 0xA5; stream[1] = 0xFF; stream[2] = 0xFF;
    memcpy(stream + 3, f_status, sizeof(f_status)); before = referee_rx_valid_frames;
    feed(stream, 3 + sizeof(f_status)); CHECK(referee_rx_valid_frames == before + 1);

    CHECK(referee_team_color(1) == 0 && referee_team_color(11) == 0);
    CHECK(referee_team_color(101) == 1 && referee_team_color(107) == 1 && referee_team_color(111) == 1);
    CHECK(referee_team_color(2) == 0xFF && referee_team_color(102) == 0xFF && referee_team_color(17) == 0xFF);
    robot_state.robot_id = 101; robot_id(); CHECK(Vision_ID == 0 && MyColour() == 1);
    robot_state.robot_id = 1; robot_id(); CHECK(Vision_ID == 1 && MyColour() == 0);
    robot_state.robot_id = 0; robot_id(); CHECK(Vision_ID == 0xFF && MyColour() == -1);
    before = transmit_count; send_test(&sent); CHECK(transmit_count == before);
    robot_state.robot_id = 3; send_test(&sent); CHECK(transmit_count == before);
    send_test(NULL); CHECK(transmit_count == before);
    robot_state.robot_id = 107;
    UI_Seq1 = 0;
    capture = fopen("sentry-tx.bin", "wb"); CHECK(capture != NULL);
    for (i = 1; i <= 6; ++i) {
        RECEIVE_ROBOT_CMD_DATA.data.speed_vector.mode = (uint8_t)i;
        sentry_activate_rune = 1;
        send_test(&sent);
        CHECK(transmitted_length == 19 && transmitted[1] == 10 && transmitted[2] == 0);
        CHECK(transmitted[5] == 1 && transmitted[6] == 3 && transmitted[7] == 0x20 && transmitted[8] == 1);
        CHECK(transmitted[9] == 107 && transmitted[11] == 0x80 && transmitted[12] == 0x80);
        CHECK(verify_CRC8_check_sum(transmitted, 5) && verify_CRC16_check_sum(transmitted, 19));
        CHECK(((sent.datahead.SENTRY.sentry_cmd >> 21) & 7) == i);
        CHECK((sent.datahead.SENTRY.sentry_cmd & (1UL << 24)) && !(sent.datahead.SENTRY.sentry_cmd & (0x7FUL << 25)));
        CHECK(fwrite(transmitted, 1, 19, capture) == 19);
    }
    fclose(capture);
    sentry_activate_rune = 0; RECEIVE_ROBOT_CMD_DATA.data.speed_vector.mode = 0;
    send_test(&sent); CHECK(((sent.datahead.SENTRY.sentry_cmd >> 21) & 7) == 3);
    CHECK(!(sent.datahead.SENTRY.sentry_cmd & (1UL << 24)));
    init_referee_struct_data();
    CHECK(referee_rx_valid_frames == 0 && referee_last_rx_tick == 0);
    CHECK(robot_custom_data.data[59] == 0 && robot_custom_data_2.data[299] == 0 && map_command.cmd_source == 0);
    printf("PASS %u checks: 2027 layouts, independent wire fixtures, CRC, split/glued RX, invalid lengths, interaction limits, sentry bits and IDs\n", checks);
    return 0;
}
